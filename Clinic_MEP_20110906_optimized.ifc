Properties of the parts of a building model (IFC2X3), part 291 of 295

# IfcFlowTerminal: 15 mm Pendent (418)
Name (M_Sprinkler - Pendent - Hosted:15 mm Pendent:15 mm Pendent:...) | In | Schedule Level | Host | Elevation (m) | Mark
1048664 | 2D05 | Level 2 | <not associated> | 2.8 | 448
1016082 | 1D10 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 125
1038035 | 2CC3 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 292
1007389 | 1D22 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 49
1011811 | 1C08 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 94
1038856 | 2CC5 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 301
1023414 | 1BC4 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 186
1034286 | 2A13 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 241
1005144 | 1E26 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 20
1045828 | 2DC1 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 405
1023024 | 1B04 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 183
1019666 | 1A05 | Level 1 | <not associated> | 2.8 | 156
1045552 | 2DC1 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 401
1034008 | 2A02 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 239
1008557 | 1DC1 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | 56
1043563 | 2D15 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 360
1044175 | 2B22 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 371
1019964 | 1A10 | Level 1 | <not associated> | 2.8 | 159
1014624 | 1DC7 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 111
1045958 | 2D04-A | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 406
1021706 | 1B09 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 173
1045310 | 2B10 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 396
1046630 | 2BC5 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 415
1021122 | 1BC2 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 166
1025747 | 1EC1 | Level 1 | <not associated> | 2.8 | 205
1006591 | 1D31 | Level 1 | <not associated> | 2.8 | 40
1003753 | 1E23 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 10
1044005 | 2BC3 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 367
1048656 | 2D05 | Level 2 | <not associated> | 2.8 | 447
1032394 | 2C03 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 225
1047669 | 2C09 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 425
1006809 | 1DC5 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 42
1043067 | 2D20 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 354
1009597 | 1D18 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 66
1023108 | 1B04 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 184
1014808 | 1DC8 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 113
1032034 | 2C04 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 222
1006425 | 1D25 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 38
1004432 | 1E24 | Level 1 | <not associated> | 2.8 | 15
1046514 | 2BC5 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 413
1022570 | 1BC2 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 178
1047136 | 2D04 | Level 2 | <not associated> | 2.8 | 422
1021928 | 1B17 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 175
1048538 | 2D05 | Level 2 | <not associated> | 2.8 | 435
1016021 | 1D12 | Level 1 | <not associated> | 2.8 | 124
1023809 | 1B06 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 194
1048476 | 2D05 | Level 2 | <not associated> | 2.8 | 429
1011481 | 1AC3 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 89
1043447 | 2D14 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 359
1036505 | 2CC1 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 266
1040324 | 2A14 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 322
1048692 | 2D05 | Level 2 | <not associated> | 2.8 | 451
1021583 | 1B05 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 171
1025556 | 1EC1 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 203
1010590 | 1D06 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 79
1021305 | 1B01 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 168
1048558 | 2D05 | Level 2 | <not associated> | 2.8 | 437
1018839 | 1A16 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 147
1044945 | 2B25 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 387
1045530 | 2BC2 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 400
1007653 | 1DC1 |  | Linked Revit Model : Clinic_A.rvt | 0 | 52
1046487 | 2B9 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 412
1025494 | 1EC1 | Level 1 | <not associated> | 2.8 | 202
1044651 | 2B15 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 380
1020856 | 1B13 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 163
1012276 | 1C06 | Level 1 | <not associated> | 2.8 | 106
1005970 | 1D25 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 34
1048700 | 2D05 | Level 2 | <not associated> | 2.8 | 452
1009912 | 1D16 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 69
1038740 | 2CC5 | Level 2 | <not associated> | 2.8 | 300
1048530 | 2D05 | Level 2 | <not associated> | 2.8 | 434
1023661 | 1B14 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 190
1044325 | 2B18 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 374
1005717 | 1E15 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 31
1005341 | 1E09 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 24
1045175 | 2B8 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 393
1005747 | 1D32 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 32
1011178 | 1C07 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 87
1011014 | 1C03 | Level 1 | <not associated> | 2.8 | 83
1011976 | 1C18 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 98
1022672 | 1B04 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 180
1039000 | 2C15 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 304
1048626 | 2D05 | Level 2 | <not associated> | 2.8 | 444
1031517 | 2A06 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 217
1045364 | 2B12 | Level 2 | <not associated> | 2.8 | 397
1023500 | 1BC3 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 187
1012147 | 1CC3 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 104
1035047 | 2AC2 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 248
1020793 | 1BC4 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 162
1012117 | 1C12 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 103
1048684 | 2D05 | Level 2 | <not associated> | 2.8 | 450
1043903 | 2BC3 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 366
1033011 | 2AC2 | Level 2 | <not associated> | 2.8 | 229
1007212 | 1DC1 | Level 1 | <not associated> | 2.8 | 46
1041023 | 2DC2 | Level 2 | <not associated> | 2.8 | 330
1011058 | 1C10 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 84
1032145 | 2CC2 | Level 2 | <not associated> | 2.8 | 223
1017327 | 1AC2 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 138
1046844 | 2B2 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 420
1046710 | 2B4 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 418
1012005 | 1C17 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 99
1019728 | 1A16 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 157
1026032 | 1E04 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 207
1009973 | 1D16 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 71
1019079 | 1A01 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 150
1032741 | 2CC2 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 227
1005624 | 1E33 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 29
1010366 | 1D09 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 77
1038613 | 2C16 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 299
1021625 | 1B07 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 172
1043115 | 2D20 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 355
1048634 | 2D05 | Level 2 | <not associated> | 2.8 | 445
1022989 | 1B04 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 182
1040474 | 2A01 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 324
1044279 | 2B20 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 373
1048604 | 2D05 | Level 2 | <not associated> | 2.8 | 442
1048566 | 2D05 | Level 2 | <not associated> | 2.8 | 438
1039082 | 2C12 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 305
1021086 | 1B15 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 165
1022133 | 1B19 | Level 1 | <not associated> | 2.8 | 176
1043339 | 2D11 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 356
1031436 | 2A05 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 216
1043878 | 2BC3 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 365
1044061 | 2BC3 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 369
1041115 | 2DC2 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 331
1046540 | 2BC5 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 414
1009355 | 1D15 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 64
1045247 | 2B8 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 394
1020183 | 1A09 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 161
1033768 | 2AC4 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 236
1044597 | 2B13 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 378
1019365 | 1A02 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 153
1042792 | 2D21 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 351
1005866 | 1D28 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 33
1040228 | 2A14 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 321
1042840 | 2D21 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 352
1021884 | 1BC2 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 174
1037950 | 2C06 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 291
1045021 | 2B01 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 389
1044967 | 2B25 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 388
1043698 | 2D19 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 362
1041971 | 2D18 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 340
1034115 | 2AC4 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 240
1045094 | 2BC5 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 390
1035435 | 2C24 | Level 2 | <not associated> | 2.8 | 251
1034559 | 2A11 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 246
1046767 | 2B3 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 419
1018974 | 1AC5 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 149
1044124 | 2BC3 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 370
1018625 | 1A16 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 146
1041502 | 2D08 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 334
1044758 | 2B23 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 384
1009949 | 1D16 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 70
1032838 | 2C01 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 228
1044388 | 2B16 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 375
1042926 | 2D21 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 353
1038889 | 2C17 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 302
1041329 | 2D07 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 333
1040556 | 2A01 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 325
1025380 | 1EC1 | Level 1 | <not associated> | 2.8 | 201
1045148 | 2B6 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 392
1007032 | 1D23 | Level 1 | <not associated> | 2.8 | 45
1048468 | 2D05 | Level 2 | <not associated> | 2.8 | 428
1044030 | 2BC3 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 368
1018437 | 1AC3 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 144
1043640 | 2D17 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 361
1034668 | 2A10 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 247
1044252 | 2B21 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 372
1022754 | 1B04 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 181
1040089 | 2A11 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 320
1006361 | 1D25 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 37
1044624 | 2B14 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 379
1023780 | 1B08 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 193
1025687 | 1EC1 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 204
1018869 | 1A16 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 148
1043375 | 2D13 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 357
1048546 | 2D05 | Level 2 | <not associated> | 2.8 | 436
1039637 | 2C19 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 310
1010271 | 1D13 | Level 1 | <not associated> | 2.8 | 75
1041944 | 2D10 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 339
1023672 | 1B12 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 191
1036420 | 2C08 | Level 2 | <not associated> | 2.8 | 265
1048708 | 2D05 | Level 2 | <not associated> | 2.8 | 453
1011152 | 1C07 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 86
1048616 | 2D05 | Level 2 | <not associated> | 2.8 | 443
1042675 | 2D18 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 349
1035131 | 2AC2 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 249
1032276 | 2C05 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 224
1034532 | 2A12 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 245
1033124 | 2AC3 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 230
1037654 | 2DC2 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 285
1009202 | 1D21 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 63
1019182 | 1A03 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 151
1048646 | 2D05 | Level 2 | <not associated> | 2.8 | 446
1041800 | 2D10 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 336
1041833 | 2D18 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 337
1048460 | 2D05 | Level 2 | <not associated> | 2.8 | 427
1042350 | 2D18 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 343
1041615 | 2D09 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 335
1043426 | 2D16 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 358
1035497 | 2C24 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 252
1044685 | 2B17 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 381
1042727 | 2D21 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 350
1045121 | 2B5 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 391
1011088 | 1C10 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 85
1034442 | 2AC5 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 243
1033832 | 2AC4 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 237
1043767 | 2BC2 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 363
1044890 | 2BC4 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 386
1042119 | 2D18 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 341
1018504 | 1A16 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 145
1023689 | 1B10 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 192
1042587 | 2D18 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 348
1042472 | 2D18 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 346
1039731 | 2C19 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 311
1042567 | 2D18 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 347
1042193 | 2D18 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 342
1043845 | 2BC2 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 364
1042392 | 2D18 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 344
1041909 | 2D18 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 338
1034479 | 2A11 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 244
1044739 | 2BC4 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 383
1034355 | 2AC5 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 242
1044802 | 2B24 | Level 2 | <not associated> | 2.8 | 385
1044720 | 2B19 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 382
1042434 | 2D18 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 345

# IfcFlowTerminal: 150 x 150 Face 300 x 300 Connection 2 (17)
Type - ElementType: 150 x 150 Face 300 x 300 Connection 2
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Offset: 2.8 m
PSet_Revit_Mechanical - Airflow - Pressure Drop: 4.2672; Flow: 8.29895
PSet_Revit_Mechanical - UpArrow: yes; RightArrow: yes; LeftArrow: yes; DownArrow: yes; System Type: Return Air
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles
PSet_Revit_Type_Dimensions - Duct Width: 0.492126; Duct Height: 0.492126; Diffuser Width: 0.15 m; Diffuser Height: 0.15 m
PSet_Revit_Type_Other - Width 1: 0.0975 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Return Diffuser:150 x 150 Face 300 x 300 Connection 2:150 x 150 Face 300 x 300 Connection 2:...) | In | TagNumber = Mark | Level | Host | System Name
1090498 | 1B23 | A | Level 1 | Rectangular Duct : Mitered Elbows / Tees | Mechanical Return Air 1
568492 | 1A03 | B | Level 1 | Rectangular Duct : Mitered Elbows / Tees | Mechanical Return Air 1
568538 | 1B15 | B | Level 1 | Rectangular Duct : Mitered Elbows / Tees | Mechanical Return Air 1
568514 | 1D30 | B | Level 1 | Level : Level 1 | Mechanical Return Air 1
566929 | 1D05 | A | Level 1 | Level : Level 1 | Mechanical Return Air 1
568530 | 1B01 | B | Level 1 | Level : Level 1 | Mechanical Return Air 1
568534 | 1BC2 | A | Level 1 | Rectangular Duct : Mitered Elbows / Tees | Mechanical Return Air 1
566991 | 1B08 | A | Level 1 | Level : Level 1 | Mechanical Return Air 1
568510 | 1D15 | C | Level 1 | Level : Level 1 | Mechanical Return Air 1
566986 | 1E22 | D | Level 1 | Level : Level 1 | Mechanical Return Air 1
568587 | 1E27 | B | Level 1 | Rectangular Duct : Mitered Elbows / Taps | Mechanical Return Air 1
568570 | 1E23 | D | Level 1 | Level : Level 1 | Mechanical Return Air 1
566996 | 1B07 | A | Level 1 | Level : Level 1 | Mechanical Return Air 1
568496 | 1A14 | B | Level 1 | Rectangular Duct : Mitered Elbows / Tees | Mechanical Return Air 1
568947 | Level 2 | A | Level 2 | Level : Level 2 | Mechanical Return Air 2
568505 | 1D19 | B | Level 1 | Level : Level 1 | Mechanical Return Air 1
568500 | 1A15 | B | Level 1 | Level : Level 1 | Mechanical Return Air 1

# IfcFlowTerminal: 200 x 200 Face 300 x 300 Connection (64)
Type - ElementType: 200 x 200 Face 300 x 300 Connection
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - UpArrow: yes; RightArrow: yes; LeftArrow: yes; DownArrow: yes; System Type: Return Air
PSet_Revit_Constraints - Offset: 2.8 m
PSet_Revit_Mechanical - Airflow - Pressure Drop: 4.2672; Flow: 8.29895
PSet_Revit_Type_Dimensions - Duct Width: 0.656168; Duct Height: 0.656168; Diffuser Width: 0.2 m; Diffuser Height: 0.2 m
PSet_Revit_Type_Other - Width 1: 0.13 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles
Name (M_Return Diffuser:200 x 200 Face 300 x 300 Connection:200 x 200 Face 300 x 300 Connection:...) | In | Mark = TagNumber | System Name | Level | Host
1090943 | 2C18 | A | Mechanical Return Air 2 | Level 2 | Rectangular Duct : Mitered Elbows / Taps
1138444 | 1E08 | D | Mechanical Return Air 1 | Level 1 | Rectangular Duct : Mitered Elbows / Taps
570499 | 1D10 | C | Mechanical Return Air 1 | Level 1 | Level : Level 1
567080 | 1E04 | D | Mechanical Return Air 1 | Level 1 | Level : Level 1
1090814 | 1E19 | D | Mechanical Return Air 1 | Level 1 | Rectangular Duct : Mitered Elbows / Tees
567219 | 1C14 | C | Mechanical Return Air 1 | Level 1 | Level : Level 1
568487 | 1A01 | D | Mechanical Return Air 1 | Level 1 | Level : Level 1
566902 | 1D36 | C | Mechanical Return Air 1 | Level 1 | Level : Level 1
566938 | 1D02 | C | Mechanical Return Air 1 | Level 1 | Level : Level 1
568471 | 1C10 | D | Mechanical Return Air 1 | Level 1 | Rectangular Duct : Mitered Elbows / Tees
566957 | 1D13 | C | Mechanical Return Air 1 | Level 1 | Level : Level 1
568468 | 1A04 | D | Mechanical Return Air 1 | Level 1 | Rectangular Duct : Mitered Elbows / Taps
568482 | 1C17 | A | Mechanical Return Air 1 | Level 1 | Rectangular Duct : Mitered Elbows / Taps
567140 | 1E05 | A | Mechanical Return Air 1 | Level 1 | Level : Level 1
568461 | 1C05 | E | Mechanical Return Air 1 | Level 1 | Rectangular Duct : Mitered Elbows / Taps
567049 | 1D27 | C | Mechanical Return Air 1 | Level 1 | Level : Level 1
568476 | 1C07 | D | Mechanical Return Air 1 | Level 1 | Rectangular Duct : Mitered Elbows / Taps
568562 | 1B10 | D | Mechanical Return Air 1 | Level 1 | Level : Level 1
568541 | 1D40 | D | Mechanical Return Air 1 | Level 1 | Level : Level 1
568451 | 1C16 | D | Mechanical Return Air 1 | Level 1 | Rectangular Duct : Mitered Elbows / Taps
568454 | 1C19 | D | Mechanical Return Air 1 | Level 1 | Rectangular Duct : Mitered Elbows / Taps
568581 | 1E25 | D | Mechanical Return Air 1 | Level 1 | Level : Level 1
567155 | 1D08 | C | Mechanical Return Air 1 | Level 1 | Level : Level 1
566918 | 1A07 | D | Mechanical Return Air 1 | Level 1 | Level : Level 1
568567 | 1E07 | D | Mechanical Return Air 1 | Level 1 | Rectangular Duct : Mitered Elbows / Taps
567161 | 1D07 | C | Mechanical Return Air 1 | Level 1 | Level : Level 1
567010 | 1D35 | C | Mechanical Return Air 1 | Level 1 | Level : Level 1
569053 | 2A12 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2
567022 | 1D34 | C | Mechanical Return Air 1 | Level 1 | Level : Level 1
569048 | 2AC5 | C | Mechanical Return Air 2 | Level 2 | Level : Level 2
568554 | 1D24 | D | Mechanical Return Air 1 | Level 1 | Level : Level 1
568551 | 1D28 | D | Mechanical Return Air 1 | Level 1 | Rectangular Duct : Mitered Elbows / Tees
568576 | 1E18 | D | Mechanical Return Air 1 | Level 1 | Level : Level 1
567021 | 1D32 | C | Mechanical Return Air 1 | Level 1 | Level : Level 1
568970 | 2D03 | C | Mechanical Return Air 2 | Level 2 | Level : Level 2
568479 | 1C15 | A | Mechanical Return Air 1 | Level 1 | Rectangular Duct : Mitered Elbows / Taps
568546 | 1D33 | D | Mechanical Return Air 1 | Level 1 | Level : Level 1
568458 | 1C08 | D | Mechanical Return Air 1 | Level 1 | Rectangular Duct : Mitered Elbows / Tees
568971 | 2D02 | C | Mechanical Return Air 2 | Level 2 | Level : Level 2
568964 | 2D01 | B | Mechanical Return Air 2 | Level 2 | Level : Level 2
568942 | 2D17 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2
568939 | 2D16 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2
567160 | 1D11 | C | Mechanical Return Air 1 | Level 1 | Level : Level 1
568938 | 2D11 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2
568952 | 2B19 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2
566923 | 1A05 | B | Mechanical Return Air 1 | Level 1 | Level : Level 1
568931 | 2C01 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2
568953 | 2B24 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2
568935 | 2D08 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2
568934 | 2D09 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2
567002 | 1B03 | C | Mechanical Return Air 1 | Level 1 | Level : Level 1
568932 | 2A10 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2
568963 | 2BC1 | B | Mechanical Return Air 2 | Level 2 | Level : Level 2
568962 | 2B8 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2
568950 | 2B18 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2
568959 | 2B15 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2
568936 | 2D07 | C | Mechanical Return Air 2 | Level 2 | Level : Level 2
568961 | 2B10 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2
568929 | 2C22 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2
568956 | 2B7 | C | Mechanical Return Air 2 | Level 2 | Level : Level 2
568924 | 2A02 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2
568960 | 2B14 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2
568957 | 2B4 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2
568958 | 2B17 | D | Mechanical Return Air 2 | Level 2 | Level : Level 2

# IfcFlowTerminal: 200mm, M_Supply Diffuser - Sidewall:200mm:200mm:1116041
In: Level 2
Type - ElementType: 200mm
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles
PSet_Revit_Other - TagNumber: A; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: A
PSet_Revit_Mechanical - Airflow - Pressure Drop: 1.524; Flow: 8.29895
PSet_Revit_Constraints - Level: Level 2; Host: Level : Level 2; Offset: 2.5 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2
PSet_Revit_Type_Dimensions - Width: 0.2 m; Height: 0.3 m; Duct Width: 0.656168; Duct Height: 0.984252
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - Half Height: 0.15 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - Airflow - Min Flow: 1130.07; Max Flow: 5297.2

# IfcFlowTerminal: 203mm Incandescent - 120V (157)
Type - ElementType: 203mm Incandescent - 120V
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Electrical - Lighting - Calculate Coefficient of Utilization: no
PSet_Revit_Electrical - Circuiting - Electrical Data: 120 V/1-100 VA
PSet_Revit_Type_Electrical - Loads - Apparent Load: 1076.39
PSet_Revit_Type_Photometrics - Light Source Definition (family): Point+HemiSpherical; Light Loss Factor: 0; Initial Intensity: 0; Initial Color: 0; Dimming Lamp Color Temperature Shift: 0; Color Filter: 16777215
PSet_Revit_Type_Dimensions - Recessing Height: 0.2 m; Recessing Diameter: 0.2 m; Light Source Symbol Size: 0.05 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; Assembly Code: D5020220; Assembly Description: Lighting - Incandescent; OmniClass Number: 23.80.70.11.14.11; OmniClass Title: Downlights
PSet_Revit_Type_Other - Recessing Radius: 0.1 m; Recessing Inner Radius: 0.0873 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Electrical - Load Classification: Lighting - Dwelling Unit; Lamp: A-19; Ballast Voltage: 1291.67; Ballast Number of Poles: 1
PSet_Revit_Type_Constraints - Default Elevation: 1.2 m
Name (M_Downlight - Recessed Can:203mm Incandescent - 120V:203mm Incandescent - 120V:...) | In | Mark = TagNumber | Schedule Level | Host | Elevation (m) | Panel | Circuit Number
827108 | 1B19 | SD | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41B | 1
827428 | Level 1 | SD | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41B | 6
827488 | Level 1 | SD | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41B | 6
746973 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41C | 6
850647 | 2D12 | SE | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 6
753990 | 1AC1 | LV | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.5 | L41C | 7
827479 | Level 1 | SDB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41B | 6
927365 | 1DC1 | T1 | Level 1 | <not associated> | 2.5 | L41C | 8
809668 | 1D18 | SA | Level 1 | <not associated> | 2.8 | L41C | 5
927298 | 1DC1 | T1 | Level 1 | <not associated> | 2.5 | L41C | 8
779444 | 2AC1 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 3
780568 | 2D13 | SE | Level 2 | <not associated> | 2.8 | L42B | 6
779597 | 2C23 | E2 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 2
751529 | 1DC1 | LV | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.5 | L41C | 8
746910 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | L41C | 6
927219 | 1DC1 | LV | Level 1 | <not associated> | 2.5 | L41C | 8
750152 | 1AC1 | SD | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41B | 2
779480 | 2AC1 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 3
746870 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | L41C | 6
746741 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | L41C | 6
782665 | 2D04-A | M400 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 2
780882 | 2D10 | SD | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 6
783090 | 2C08 | SA | Level 2 | <not associated> | 2.8 | L42C | 2
749899 | 1AC1 | SD | Level 1 | Linked Revit Model : Clinic_A.rvt | 3.8 | L41C | 2
780518 | 2D11 | SE | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 6
779644 | 2C03 | E2 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 2
809705 | 1D18 | E2 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41C | 5
782227 | 2AC1 | SB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 4
779322 | 2AC1 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 3
927229 | 1DC1 | LV | Level 1 | <not associated> | 2.5 | L41C | 8
782024 | 2BC1 | SB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 4
748855 | 1C10 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
746836 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | L41C | 6
784102 | 2C07 | SA | Level 2 | <not associated> | 2.8 | L42C | 2
778744 | 2A01 | S | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 6
779113 | 2AC1 | SCB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 3
779979 | 2AS1 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 7
748650 | 1C02 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
782263 | 2AC1 | SB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 4
750055 | 1AC1 | SDB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41B | 2
780461 | 2D11 | SE | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 6
749926 | 1AC1 | SD | Level 1 | Linked Revit Model : Clinic_A.rvt | 3.8 | L41C | 2
748879 | 1C10 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
780723 | 2D18 | SBB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 5
780694 | 2D18 | SB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 5
751943 | 1AC1 | LV | Level 1 | Linked Revit Model : Clinic_A.rvt | 3.8 | L41C | 7
927191 | 1DC1 | LV | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.5 | L41C | 8
778608 | 2A01 | S | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 6
782453 | 2D03 | M400 | Level 2 | <not associated> | 2.8 | L42B | 2
748764 | 1C10 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
783538 | 2A03 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 6
749526 | 1AC2 | SD | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41C | 2
779368 | 2AC1 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 3
749576 | 1AC2 | SD | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41C | 2
779408 | 2AC1 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 3
749954 | 1AC1 | SDB | Level 1 | Linked Revit Model : Clinic_A.rvt | 3.8 | L41C | 2
781817 | 2B11 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 4
780754 | 2D10 | SD | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 6
780097 | 2AS1 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 7
778151 | 2A01 | S | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 6
780417 | 2D11 | SE | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 6
748712 | 1C02 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
779188 | 2AC1 | SCB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 3
752303 | 1AC1 | LV | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.5 | L41C | 7
779791 | 2AS1 | SCB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 7
783430 | 2A04 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 6
783825 | 2A12-A | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 7
751761 | 1AC1 | LV | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.5 | L41C | 7
781328 | 2D18 | SB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 5
781098 | 2D18 | SB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 5
778414 | 2A01 | S | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 6
783478 | 2A03 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 6
781949 | 2B11 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 4
751885 | 1AC1 | LV | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | L41C | 7
749099 | 1C07 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
748928 | 1C10 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
751813 | 1AC1 | LV | Level 1 | <not associated> | 2.5 | L41C | 7
752081 | 1AC1 | LV | Level 1 | Linked Revit Model : Clinic_A.rvt | 3.8 | L41C | 7
752368 | 1AC1 | LV | Level 1 | <not associated> | 2.5 | L41C | 7
780057 | 2AS1 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 7
747543 | 1D22 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41C | 5
749997 | 1AC1 | SD | Level 1 | Linked Revit Model : Clinic_A.rvt | 3.8 | L41C | 2
782159 | 2BC1 | SBB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 4
778668 | 2A01 | S | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 6
780357 | 2D11 | SE | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 6
781897 | 2B11 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 4
748906 | 1C10 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
779006 | 2A14 | M175 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 7
752026 | 1AC1 | LV | Level 1 | Linked Revit Model : Clinic_A.rvt | 3.8 | L41C | 7
779853 | 2AS1 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 7
781853 | 2B11 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 4
751607 | 1AC1 | LV | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.5 | L41C | 7
778364 | 2A01 | S | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 6
747509 | 1D22 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41C | 5
778229 | 2A01 | S | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 6
749067 | 1C07 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
747095 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | L41C | 6
749133 | 1C07 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
782392 | 2D03 | M250 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 2
781384 | 2D18 | SBB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 5
747680 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41C | 6
779939 | 2AS1 | SCB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 7
749027 | 1C07 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
748970 | 1C07 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
747461 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | L41C | 6
780978 | 2D18 | SBB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 5
782187 | 2BC1 | SBB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 4
781249 | 2D18 | SBB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 5
782613 | 2D04-A | M400 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 2
752424 | 1AC1 | LV | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.5 | L41C | 7
783354 | 2A04 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 6
780013 | 2AS1 | SCB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 7
781411 | 2D18 | SB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 5
781128 | 2D18 | SBB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 5
783739 | 2A13 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 7
781444 | 2D18 | SB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 5
747315 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | L41C | 6
749805 | 1AC1 | SD | Level 1 | Linked Revit Model : Clinic_A.rvt | 3.8 | L41C | 2
747745 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | L41C | 6
778810 | 2A01 | S | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 6
782088 | 2BC1 | SB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 4
781769 | 2B11 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 4
783402 | 2A04 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 6
747203 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | L41C | 6
781289 | 2D18 | SB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 5
747965 | 1DC1 | SBB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41C | 6
779897 | 2AS1 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 7
781069 | 2D18 | SBB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 5
780937 | 2D18 | SB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 5
747370 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | L41C | 6
751662 | 1AC1 | LV | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | L41C | 7
778312 | 2A01 | S | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 6
781006 | 2D18 | SB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 5
749482 | 1AC2 | SDB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41C | 2
747243 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | L41C | 6
781184 | 2D18 | SB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 5
747783 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | L41C | 6
748022 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | L41C | 6
749843 | 1AC1 | SDB | Level 1 | Linked Revit Model : Clinic_A.rvt | 3.8 | L41C | 2
783580 | 2A03 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42C | 6
781718 | 2B11 | SC | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 4
749727 | 1AC1 | SDB | Level 1 | Linked Revit Model : Clinic_A.rvt | 3.8 | L41C | 2
749876 | 1AC1 | SD | Level 1 | Linked Revit Model : Clinic_A.rvt | 3.8 | L41C | 2
747929 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | L41C | 6
748138 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | L41C | 6
781031 | 2D18 | SB | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 5
748516 | 1C01 | SD | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
780905 | 2D10 | SD | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | L42B | 6
749761 | 1AC1 | SD | Level 1 | Linked Revit Model : Clinic_A.rvt | 3.8 | L41C | 2
747831 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | L41C | 6
748080 | 1DC1 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | L41C | 6
749379 | 1AC2 | SD | Level 1 | <not associated> | 2.8 | L41C | 2
748571 | 1C01 | SD | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
748538 | 1C01 | SD | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
749654 | 1AC1 | SD | Level 1 | Linked Revit Model : Clinic_A.rvt | 3.8 | L41C | 2
748450 | 1C01 | SD | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22
748595 | 1C02 | SB | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | N21C1 | 22

# IfcFlowTerminal: 225 A (28)
Type - ElementType: 225 A
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_General - Mounting: Recessed; Enclosure: Type 1
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Elevation: 1.2 m; Offset: 0 m
PSet_Revit_Electrical - Circuiting - Mains: 100; Distribution System: 120/208 Wye; Number of Wires: 4; Number of Phases: 3; Electrical Data: 208 V/3-0 VA
PSet_Revit_Type_Electrical - Load Classification: Other
PSet_Revit_Type_Constraints - Default Elevation: 1.2 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels
PSet_Revit_Type_Dimensions - Width: 0.508 m; Depth: 0.1461 m; 42 Circuit Height: 1.0414 m; 30 Circuit Height: 0.8128 m; 24 Circuit Height: 0.8128 m; 12 Circuit Height: 0.8128 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Lighting and Appliance Panelboard - 208V MLO:225 A:...) | In | Panel Name = TagNumber | Location | Schedule Level | Height (m) | Host | Max #1 Pole Breakers | Supply From | Total Connected | Total Estimated Demand | Total Demand Factor | Total Connected Current | Total Estimated Demand Current | Apparent Load Phase A | Apparent Load Phase B | Apparent Load Phase C | Current Phase A | Current Phase B | Current Phase C | Mark
F42C:938813 | 2C18 | F42C | ELECTRICAL 2C18-M | Level 2 | 1.0414 | Linked Revit Model : Clinic_A.rvt | 36 | MS2 | 324101 | 134425 | 0.414763 | 83.577 | 34.6646 | 145743 | 89082.1 | 89275.9 | 112.833 | 68.9667 | 69.1167 | 24 | PSet_Revit_Electrical - Loads - Other Connected: 0; Other Estimated Demand: 0; Other Connected Current: 0; Other Estimated Demand Current: 0; Lighting - Dwelling Unit Connected: 324101; Lighting - Dwelling Unit Estimated Demand: 134425; Lighting - Dwelling Unit Connected Current: 83.577; Lighting - Dwelling Unit Estimated Demand Current: 34.6646; Lighting - Dwelling Unit Demand Factor: 0.414763
N22B1:936279 | 2B13 | N22B1 | ELECTRICAL 2B13-M | Level 2 | 1.0414 | Grid : C | 36 | F22B | 205375 | 156507 | 0.762055 | 52.9608 | 40.359 | 79437.7 | 75562.7 | 50375.1 | 61.5 | 58.5 | 39 | 19 | PSet_Revit_Electrical - Loads - Receptacle Connected: 205375; Receptacle Estimated Demand: 156507; Receptacle Connected Current: 52.9608; Receptacle Estimated Demand Current: 40.359; Receptacle Demand Factor: 0.762055
N22B2:936228 | 2B13 | N22B2 | ELECTRICAL 2B13-M | Level 2 | 0.8128 | Grid : C | 12 | F22B | 0 | 0 | 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 18
1MEC:1063416 | 1E15 | 1MEC | CENTRAL MECH. RM. 1E15-M | Level 1 | 0.8128 | Linked Revit Model : Clinic_A.rvt | 12 |  | 11194.5 | 11194.5 | 1 | 2.88675 | 2.88675 | 3731.49 | 3731.49 | 3731.49 | 2.88889 | 2.88889 | 2.88889 | 32 | PSet_Revit_Electrical - Loads - Cooling Connected: 11194.5; Cooling Estimated Demand: 11194.5; Cooling Connected Current: 2.88675; Cooling Estimated Demand Current: 2.88675; Cooling Demand Factor: 1
L42B:936522 | 2B13 | L42B | ELECTRICAL 2B13-M | Level 2 | 0.8128 | Linked Revit Model : Clinic_A.rvt | 12 | F42B | 146045 | 72105.3 | 0.493721 | 37.661 | 18.594 | 46586.2 | 42625.1 | 56833.4 | 36.0667 | 33 | 44 | 20 | PSet_Revit_Electrical - Loads - Other Connected: 0; Other Estimated Demand: 0; Other Connected Current: 0; Other Estimated Demand Current: 0; Lighting - Dwelling Unit Connected: 146045; Lighting - Dwelling Unit Estimated Demand: 72105.3; Lighting - Dwelling Unit Connected Current: 37.661; Lighting - Dwelling Unit Estimated Demand Current: 18.594; Lighting - Dwelling Unit Demand Factor: 0.493721
F22B:937316 | 2B13 | F22B | ELECTRICAL 2B13-M | Level 2 | 0.8128 | Linked Revit Model : Clinic_A.rvt | 24 | MS2 | 713001 | 410320 | 0.575483 | 183.864 | 105.811 | 273188 | 230563 | 209250 | 211.5 | 178.5 | 162 | 23 | PSet_Revit_Electrical - Loads - Receptacle Connected: 713001; Receptacle Estimated Demand: 410320; Receptacle Connected Current: 183.864; Receptacle Estimated Demand Current: 105.811; Receptacle Demand Factor: 0.575483
N21E1:858660 | 1E19 | N21E1 | ELEC. ROOM 1E19-M | Level 1 | 1.0414 | Linked Revit Model : Clinic_A.rvt | 36 | F21E | 174375 | 141007 | 0.808642 | 44.9667 | 36.362 | 54250.1 | 52312.6 | 67812.6 | 42 | 40.5 | 52.5 | 2 | PSet_Revit_Electrical - Loads - Receptacle Connected: 174375; Receptacle Estimated Demand: 141007; Receptacle Connected Current: 44.9667; Receptacle Estimated Demand Current: 36.362; Receptacle Demand Factor: 0.808642
2SITE:936184 | 2B13 | 2SITE | ELECTRICAL 2B13-M | Level 2 | 0.8128 | Grid : C | 12 |  | 0 | 0 | 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 17
N21E2:858534 | 1E19 | N21E2 | ELEC. ROOM 1E19-M | Level 1 | 1.0414 | Linked Revit Model : Clinic_A.rvt | 36 | F21E | 228625 | 168132 | 0.735405 | 58.9563 | 43.3568 | 89125.2 | 65875.1 | 73625.1 | 69 | 51 | 57 | 1 | PSet_Revit_Electrical - Loads - Receptacle Connected: 228625; Receptacle Estimated Demand: 168132; Receptacle Connected Current: 58.9563; Receptacle Estimated Demand Current: 43.3568; Receptacle Demand Factor: 0.735405
N22C1:939133 | 2C18 | N22C1 | ELECTRICAL 2C18-M | Level 2 | 1.0414 | Grid : 7 | 36 | F22C | 236375 | 172007 | 0.727687 | 60.9549 | 44.356 | 73625.1 | 75562.7 | 87187.7 | 57 | 58.5 | 67.5 | 27 | PSet_Revit_Electrical - Loads - Receptacle Connected: 236375; Receptacle Estimated Demand: 172007; Receptacle Connected Current: 60.9549; Receptacle Estimated Demand Current: 44.356; Receptacle Demand Factor: 0.727687
L41C:861513 | Level 1 | L41C |  | Level 1 | 0.8128 | Grid : 6.7 | 12 | F42C | 166991 | 79436.6 | 0.475693 | 43.0626 | 20.4846 | 68027.9 | 40472.3 | 58491.1 | 52.6667 | 31.3333 | 45.2833 | 16 | PSet_Revit_Electrical - Loads - Other Connected: 0; Other Estimated Demand: 0; Other Connected Current: 0; Other Estimated Demand Current: 0; Lighting - Dwelling Unit Connected: 166991; Lighting - Dwelling Unit Estimated Demand: 79436.6; Lighting - Dwelling Unit Connected Current: 43.0626; Lighting - Dwelling Unit Estimated Demand Current: 20.4846; Lighting - Dwelling Unit Demand Factor: 0.475693
2MEC:939396 | 2C18 | 2MEC | ELECTRICAL 2C18-M | Level 2 | 0.8128 | Linked Revit Model : Clinic_A.rvt | 12 |  | 11194.5 | 11194.5 | 1 | 2.88675 | 2.88675 | 3731.49 | 3731.49 | 3731.49 | 2.88889 | 2.88889 | 2.88889 | 30 | PSet_Revit_Electrical - Loads - Cooling Connected: 11194.5; Cooling Estimated Demand: 11194.5; Cooling Connected Current: 2.88675; Cooling Estimated Demand Current: 2.88675; Cooling Demand Factor: 1
F42B:936707 | 2B13 | F42B | ELECTRICAL 2B13-M | Level 2 | 0.8128 | Linked Revit Model : Clinic_A.rvt | 12 | MS2 | 309742 | 129399 | 0.417765 | 79.8742 | 33.3686 | 121718 | 87058.5 | 100965 | 94.2333 | 67.4 | 78.1667 | 21 | PSet_Revit_Electrical - Loads - Other Connected: 0; Other Estimated Demand: 0; Other Connected Current: 0; Other Estimated Demand Current: 0; Lighting - Dwelling Unit Connected: 309742; Lighting - Dwelling Unit Estimated Demand: 129399; Lighting - Dwelling Unit Connected Current: 79.8742; Lighting - Dwelling Unit Estimated Demand Current: 33.3686; Lighting - Dwelling Unit Demand Factor: 0.417765
N22B:937047 | 2B13 | N22B | ELECTRICAL 2B13-M | Level 2 | 1.0414 | Linked Revit Model : Clinic_A.rvt | 36 | F22B | 193750 | 150695 | 0.777778 | 49.963 | 38.8601 | 77500.2 | 58125.1 | 58125.1 | 60 | 45 | 45 | 22 | PSet_Revit_Electrical - Loads - Receptacle Connected: 193750; Receptacle Estimated Demand: 150695; Receptacle Connected Current: 49.963; Receptacle Estimated Demand Current: 38.8601; Receptacle Demand Factor: 0.777778
N21C:861177 | Level 1 | N21C |  | Level 1 | 1.0414 | Grid : 6.7 | 36 | F22C | 178250 | 142945 | 0.801932 | 45.966 | 36.8616 | 77500.2 | 58125.1 | 42625.1 | 60 | 45 | 33 | 14 | PSet_Revit_Electrical - Loads - Receptacle Connected: 178250; Receptacle Estimated Demand: 142945; Receptacle Connected Current: 45.966; Receptacle Estimated Demand Current: 36.8616; Receptacle Demand Factor: 0.801932
N21B2:860552 | 1B23 | N21B2 | ELEC. ROOM 1B23-M | Level 1 | 0.8128 | Linked Revit Model : Clinic_A.rvt | 12 | F22B | 0 | 0 | 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 10
N22C2:939184 | 2C18 | N22C2 | ELECTRICAL 2C18-M | Level 2 | 0.8128 | Grid : 7 | 12 | F22C | 3875.01 | 3875.01 | 1 | 0.99926 | 0.99926 | 3875.01 | 0 | 0 | 3 | 0 | 0 | 28 | PSet_Revit_Electrical - Loads - Receptacle Connected: 3875.01; Receptacle Estimated Demand: 3875.01; Receptacle Connected Current: 0.99926; Receptacle Estimated Demand Current: 0.99926; Receptacle Demand Factor: 1
N22C:939057 | 2C18 | N22C | ELECTRICAL 2C18-M | Level 2 | 1.0414 | Grid : 7 | 36 | F22C | 187938 | 147788 | 0.786369 | 48.4641 | 38.1107 | 67812.6 | 62000.1 | 58125.1 | 52.5 | 48 | 45 | 26 | PSet_Revit_Electrical - Loads - Receptacle Connected: 187938; Receptacle Estimated Demand: 147788; Receptacle Connected Current: 48.4641; Receptacle Estimated Demand Current: 38.1107; Receptacle Demand Factor: 0.786369
L42C:939569 | 2C18 | L42C | ELECTRICAL 2C18-M | Level 2 | 0.8128 | Linked Revit Model : Clinic_A.rvt | 12 | F42C | 157110 | 75978.1 | 0.483598 | 40.5144 | 19.5927 | 77715.4 | 48609.8 | 30784.8 | 60.1667 | 37.6333 | 23.8333 | 31 | PSet_Revit_Electrical - Loads - Other Connected: 0; Other Estimated Demand: 0; Other Connected Current: 0; Other Estimated Demand Current: 0; Lighting - Dwelling Unit Connected: 157110; Lighting - Dwelling Unit Estimated Demand: 75978.1; Lighting - Dwelling Unit Connected Current: 40.5144; Lighting - Dwelling Unit Estimated Demand Current: 19.5927; Lighting - Dwelling Unit Demand Factor: 0.483598
N21C1:861212 | Level 1 | N21C1 |  | Level 1 | 1.0414 | Grid : 6.7 | 36 | F22C | 191985 | 162929 | 0.848654 | 49.5078 | 42.015 | 52312.6 | 81504.3 | 58168.2 | 40.5 | 63.1 | 45.0333 | 15 | PSet_Revit_Electrical - Loads - Other Connected: 0; Other Estimated Demand: 0; Other Connected Current: 0; Other Estimated Demand Current: 0; Lighting - Dwelling Unit Connected: 52484.8; Lighting - Dwelling Unit Estimated Demand: 39359.3; Lighting - Dwelling Unit Connected Current: 13.5344; Lighting - Dwelling Unit Estimated Demand Current: 10.1497; Lighting - Dwelling Unit Demand Factor: 0.749918; Receptacle Connected: 139500; Receptacle Estimated Demand: 123570; Receptacle Connected Current: 35.9734; Receptacle Estimated Demand Current: 31.8653; Receptacle Demand Factor: 0.885802
E41E:859289 | 1E19 | E41E | ELEC. ROOM 1E19-M | Level 1 | 0.8128 | Linked Revit Model : Clinic_A.rvt | 12 | F41E | 0 | 0 | 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6
F22C:938873 | 2C18 | F22C | ELECTRICAL 2C18-M | Level 2 | 1.0414 | Linked Revit Model : Clinic_A.rvt | 36 | MS2 | 798424 | 466148 | 0.583836 | 205.892 | 120.207 | 275126 | 277192 | 246106 | 213 | 214.6 | 190.533 | 25 | PSet_Revit_Electrical - Loads - Other Connected: 0; Other Estimated Demand: 0; Other Connected Current: 0; Other Estimated Demand Current: 0; Lighting - Dwelling Unit Connected: 52484.8; Lighting - Dwelling Unit Estimated Demand: 39359.3; Lighting - Dwelling Unit Connected Current: 13.5344; Lighting - Dwelling Unit Estimated Demand Current: 10.1497; Lighting - Dwelling Unit Demand Factor: 0.749918; Receptacle Connected: 745939; Receptacle Estimated Demand: 426789; Receptacle Connected Current: 192.358; Receptacle Estimated Demand Current: 110.057; Receptacle Demand Factor: 0.57215
L41B:860639 | 1B23 | L41B | ELEC. ROOM 1B23-M | Level 1 | 0.8128 | Linked Revit Model : Clinic_A.rvt | 12 | F42B | 163698 | 78283.8 | 0.478222 | 42.2132 | 20.1873 | 75132.1 | 44433.4 | 44132 | 58.1667 | 34.4 | 34.1667 | 11 | PSet_Revit_Electrical - Loads - Other Connected: 0; Other Estimated Demand: 0; Other Connected Current: 0; Other Estimated Demand Current: 0; Lighting - Dwelling Unit Connected: 163698; Lighting - Dwelling Unit Estimated Demand: 78283.8; Lighting - Dwelling Unit Connected Current: 42.2132; Lighting - Dwelling Unit Estimated Demand Current: 20.1873; Lighting - Dwelling Unit Demand Factor: 0.478222
N21B1:860405 | 1B23 | N21B1 | ELEC. ROOM 1B23-M | Level 1 | 1.0414 | Grid : C | 36 | F22B | 178250 | 142945 | 0.801932 | 45.966 | 36.8616 | 65875.1 | 58125.1 | 54250.1 | 51 | 45 | 42 | 9 | PSet_Revit_Electrical - Loads - Receptacle Connected: 178250; Receptacle Estimated Demand: 142945; Receptacle Connected Current: 45.966; Receptacle Estimated Demand Current: 36.8616; Receptacle Demand Factor: 0.801932
N21B:860380 | 1B23 | N21B | ELEC. ROOM 1B23-M | Level 1 | 1.0414 | Grid : C | 36 | F22B | 135625 | 121632 | 0.896825 | 34.9741 | 31.3657 | 50375.1 | 38750.1 | 46500.1 | 39 | 30 | 36 | 8 | PSet_Revit_Electrical - Loads - Receptacle Connected: 135625; Receptacle Estimated Demand: 121632; Receptacle Connected Current: 34.9741; Receptacle Estimated Demand Current: 31.3657; Receptacle Demand Factor: 0.896825
F41E:859225 | 1E19 | F41E | ELEC. ROOM 1E19-M | Level 1 | 0.8128 | Linked Revit Model : Clinic_A.rvt | 12 | MS2 | 0 | 0 | 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 5
N21E:858856 | 1E19 | N21E | ELEC. ROOM 1E19-M | Level 1 | 0.8128 | Linked Revit Model : Clinic_A.rvt | 12 | F21E | 0 | 0 | 1 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3
F21E:859016 | 1E19 | F21E | ELEC. ROOM 1E19-M | Level 1 | 0.8128 | Linked Revit Model : Clinic_A.rvt | 12 | MS2 | 403001 | 255320 | 0.633547 | 103.923 | 65.8401 | 143375 | 118188 | 141438 | 111 | 91.5 | 109.5 | 4 | PSet_Revit_Electrical - Loads - Receptacle Connected: 403001; Receptacle Estimated Demand: 255320; Receptacle Connected Current: 103.923; Receptacle Estimated Demand Current: 65.8401; Receptacle Demand Factor: 0.633547

# IfcFlowTerminal: 2400mm - 120V (13)
Type - ElementType: 2400mm - 120V
PSet_Revit_Identity Data - Mark: P1
PSet_Revit_Constraints - Host: Linked Revit Model : Clinic_A.rvt
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Electrical - Lighting - Calculate Coefficient of Utilization: no
PSet_Revit_Other - TagNumber: P1; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Electrical - Circuiting - Electrical Data: 120 V/1-150 VA
PSet_Revit_Type_Photometrics - Light Source Definition (family): Point+HemiSpherical; Light Loss Factor: 0; Initial Intensity: 0; Initial Color: 0; Dimming Lamp Color Temperature Shift: 0; Color Filter: 16777215
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.80.70.11.11; OmniClass Title: General Luminaries, Non Directional
PSet_Revit_Type_Materials and Finishes - Light Casing Material: Metal - Paint Finish - Ivory, Glossy; Diffuser Material: Glass - White, High Luminance; Ceiling Mount Material: Metal - Paint Finish - Ivory, Glossy
PSet_Revit_Type_Electrical - Load Classification: Lighting - Dwelling Unit; Lamp: T-12; Ballast Voltage: 1291.67; Ballast Number of Poles: 1
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Dimensions - Light Source Symbol Size: 0.05 m; Light Casing Length: 2.4 m; Drop From Ceiling: 0.3 m
PSet_Revit_Type_Constraints - Default Elevation: 1.2 m
PSet_Revit_Type_Electrical - Loads - Apparent Load: 1614.59
Name (M_Pendant Light - Linear - 2 Lamp:2400mm - 120V:2400mm - 120V:...) | In | Elevation (m) | Schedule Level | Panel | Circuit Number
746494 | 1DC1 | 2.68 | Level 1 | L41C | 6
746439 | 1DC1 | 2.68 | Level 1 | L41C | 6
746342 | 1DC1 | 2.8 | Level 1 | L41C | 6
746382 | 1DC1 | 2.8 | Level 1 | L41C | 6
746528 | 1DC1 | 2.68 | Level 1 | L41C | 6
