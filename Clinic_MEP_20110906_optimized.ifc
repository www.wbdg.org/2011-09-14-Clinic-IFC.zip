Properties of the parts of a building model (IFC2X3), part 39 of 295

# IfcFlowFitting: Transition - Generic (1536)
Name (M_Transition - Generic:Transition - Generic:Transition - Generic:...) | In | Mark | System Type | System Name | Width Offset | Visibility 3 | Visibility 2 | Visibility 1 | Max Fitting Outside Diameter 12 | Height Offset | Fitting Outside Radius 2 = Insulation Radius 2 | Fitting Outside Radius 1 = Insulation Radius 1 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level | Host | Offset (m) | Tick Size 2 | Tick Size 1 | Nominal Radius 2 | Nominal Radius 1 | Nominal Diameter 2 | Nominal Diameter 1 | Length | Fitting Outside Diameter 2 | Fitting Outside Diameter 1 | Size | OffsetHeight | OffsetWidth
680152 | TOF Footing | 5106 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
646099 | TOF Footing | 3010 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0572917 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.434913 | 0.0458333 | 0.1375 | 0.0524934 | 0.164042 | 0.104987 | 0.328084 | 0.0859375 | 0.114583 | 0.34375 | 100 mmø-32 mmø | 0.164042 | 0.164042
648294 | 1C16 | 3269 | Sanitary | Sanitary 1 | 9.98588 | no | no | yes | 0.114583 | 10 | 0.0572917 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0 | 0.0458333 | 0.0458333 | 0.0524934 | 0.0524934 | 0.104987 | 0.104987 | 0.0286458 | 0.114583 | 0.114583 | 32 mmø-32 mmø | 0.0524934 | 0.0383751
679766 | TOF Footing | 5069 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
1004896 | 1E24 | 10332 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1076384 | Level 1 | 13879 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.2 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
690507 | TOF Footing | 6295 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0260417 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0375 | 0.0246063 | 0.0410105 | 0.0492126 | 0.082021 | 0.0234375 | 0.0520833 | 0.09375 | 25 mmø-15 mmø | 0.0410105 | 0.0410105
1078213 | 1D31 | 14019 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.5 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
1013166 | 1D15 | 10719 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1030122 | 2D17 | 11825 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
686394 | TOF Footing | 5788 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
709179 | TOF Footing | 8484 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1050028 | 2D20 | 12492 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
698926 | 1D08 | 7240 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.46031 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
633298 | TOF Footing | 1414 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.130208 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.104167 | 0.1375 | 0.131234 | 0.164042 | 0.262467 | 0.328084 | 0.0859375 | 0.260417 | 0.34375 | 100 mmø-80 mmø | 0.164042 | 0.164042
1060904 | 1D18 | 13435 | Domestic Hot Water | Domestic Hot Water 1 | 10 | yes | no | no | 0.21875 | 10 | 0.109375 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0875 | 0.0541667 | 0.106627 | 0.0656168 | 0.213255 | 0.131234 | 0.0546875 | 0.21875 | 0.135417 | 65 mmø-40 mmø | 0.0656168 | 0.0656168
678796 | TOF Footing | 4963 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0375 | 0.0708333 | 0.0410105 | 0.082021 | 0.082021 | 0.164042 | 0.0442708 | 0.09375 | 0.177083 | 50 mmø-25 mmø | 0.082021 | 0.082021
1050514 | 2B13 | 12640 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1027141 | 1B04 | 11312 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
691335 | TOF Footing | 6422 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0260417 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0375 | 0.0246063 | 0.0410105 | 0.0492126 | 0.082021 | 0.0234375 | 0.0520833 | 0.09375 | 25 mmø-15 mmø | 0.0410105 | 0.0410105
709022 | TOF Footing | 8458 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.114583 | 10 | 0.0364583 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0458333 | 0.0328084 | 0.0524934 | 0.0656168 | 0.104987 | 0.0286458 | 0.0729167 | 0.114583 | 32 mmø-20 mmø | 0.0524934 | 0.0524934
1027714 | 1A03 | 11484 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
705352 | TOF Footing | 7992 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.25 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1029107 | 2BC2 | 11726 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.130208 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.98519 | 0.104167 | 0.204167 | 0.131234 | 0.246063 | 0.262467 | 0.492126 | 0.127604 | 0.260417 | 0.510417 | 150 mmø-80 mmø | 0.246063 | 0.246063
1050884 | 2B25 | 12752 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
688482 | TOF Footing | 6058 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1026980 | 1B10 | 11260 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 9.98908 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0546966 | 0.0656168
695254 | 1C07 | 6792 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.114583 | 10 | 0.0260417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0458333 | 0.0246063 | 0.0524934 | 0.0492126 | 0.104987 | 0.0286458 | 0.0520833 | 0.114583 | 32 mmø-15 mmø | 0.0524934 | 0.0524934
644025 | TOF Footing | 2791 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
687651 | Level 1 | 5944 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0260417 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.6 | 0.0208333 | 0.0375 | 0.0246063 | 0.0410105 | 0.0492126 | 0.082021 | 0.0234375 | 0.0520833 | 0.09375 | 25 mmø-15 mmø | 0.0410105 | 0.0410105
1013938 | 1D06 | 10963 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.017 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0825816 | 0.0656168
1027549 | 1A15 | 11428 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0135 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.07914 | 0.0656168
700248 | TOF Footing | 7393 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
679575 | Level 1 | 5056 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.046875 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.657288 | 0.0375 | 0.0541667 | 0.0410105 | 0.0656168 | 0.082021 | 0.131234 | 0.0338542 | 0.09375 | 0.135417 | 40 mmø-25 mmø | 0.0656168 | 0.0656168
646273 | TOF Footing | 3050 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.461436 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
1030271 | 2D05 | 11849 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
702389 | TOF Footing | 7613 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.114583 | 10 | 0.046875 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0375 | 0.0458333 | 0.0410105 | 0.0524934 | 0.082021 | 0.104987 | 0.0286458 | 0.09375 | 0.114583 | 32 mmø-25 mmø | 0.0524934 | 0.0524934
702412 | TOF Footing | 7619 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0364583 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0375 | 0.0328084 | 0.0410105 | 0.0656168 | 0.082021 | 0.0234375 | 0.0729167 | 0.09375 | 25 mmø-20 mmø | 0.0410105 | 0.0410105
1013271 | 1D16 | 10755 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
717496 | 1C10 | 9352 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1030104 | 2D19 | 11821 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
682183 | TOF Footing | 5327 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0677083 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0541667 | 0.1375 | 0.0656168 | 0.164042 | 0.131234 | 0.328084 | 0.0859375 | 0.135417 | 0.34375 | 100 mmø-40 mmø | 0.164042 | 0.164042
1050829 | 2B8 | 12736 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
698523 | 1DC3 | 7181 | Domestic Cold Water | Domestic Cold Water 1 | 10 | yes | no | no | 0.0729167 | 10 | 0.0364583 | 0.0260417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0291667 | 0.0208333 | 0.0328084 | 0.0246063 | 0.0656168 | 0.0492126 | 0.0182292 | 0.0729167 | 0.0520833 | 20 mmø-15 mmø | 0.0246063 | 0.0246063
637530 | TOF Footing | 2038 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0572917 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.501123 | 0.0458333 | 0.1375 | 0.0524934 | 0.164042 | 0.104987 | 0.328084 | 0.0859375 | 0.114583 | 0.34375 | 100 mmø-32 mmø | 0.164042 | 0.164042
659108 | 1D13 | 3772 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0677083 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.0541667 | 0.1375 | 0.0656168 | 0.164042 | 0.131234 | 0.328084 | 0.0859375 | 0.135417 | 0.34375 | 100 mmø-40 mmø | 0.164042 | 0.164042
644093 | TOF Footing | 2799 | Undefined |  | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.434912 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
679924 | TOF Footing | 5084 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1030138 | 2D15 | 11829 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
717592 | 1C07 | 9358 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.114583 | 10 | 0.0260417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0458333 | 0.0246063 | 0.0524934 | 0.0492126 | 0.104987 | 0.0286458 | 0.0520833 | 0.114583 | 32 mmø-15 mmø | 0.0524934 | 0.0524934
718493 | 1C07 | 9415 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1013806 | 1CC1 | 10919 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0087 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0742994 | 0.0656168
1050180 | 2B20 | 12544 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
719389 | 1A05 | 9511 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.45 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
701199 | TOF Footing | 7497 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1025938 | 1E01 | 11075 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
684583 | TOF Footing | 5569 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1047936 | 2CC3 | 11996 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
703976 | TOF Footing | 7837 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1030867 | 2C19 | 11869 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
1078232 | 1D31 | 14021 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.610319 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
683401 | TOF Footing | 5410 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.434912 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
660945 | 1C13 | 3993 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.260417 | 10 | 0.0885417 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.0708333 | 0.104167 | 0.082021 | 0.131234 | 0.164042 | 0.262467 | 0.0651042 | 0.177083 | 0.260417 | 80 mmø-50 mmø | 0.131234 | 0.131234
690253 | TOF Footing | 6272 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
641155 | TOF Footing | 2420 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.460312 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
655123 | 1B05 | 3402 | Sanitary | Default Sanitary (cskender) | 10 | yes | no | no | 0.177083 | 10 | 0.0885417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0 | 0.0708333 | 0.0458333 | 0.082021 | 0.0524934 | 0.164042 | 0.104987 | 0.0442708 | 0.177083 | 0.114583 | 50 mmø-32 mmø | 0.0524934 | 0.0524934
1053311 | 2AC4 | 13378 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1053099 | 2B2 | 13330 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
686832 | TOF Footing | 5848 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
1048974 | 2D05 | 12192 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1080891 | TOF Footing | 14233 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.114583 | 10 | 0.0260417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0458333 | 0.0246063 | 0.0524934 | 0.0492126 | 0.104987 | 0.0286458 | 0.0520833 | 0.114583 | 32 mmø-15 mmø | 0.0524934 | 0.0524934
693255 | Level 1 | 6606 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0677083 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0541667 | 0.1375 | 0.0656168 | 0.164042 | 0.131234 | 0.328084 | 0.0859375 | 0.135417 | 0.34375 | 100 mmø-40 mmø | 0.164042 | 0.164042
1013221 | 1D18 | 10735 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1013251 | 1D16 | 10751 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
699444 | 1D16 | 7306 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
1013445 | 1C10 | 10819 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
705337 | TOF Footing | 7990 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.25 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
684877 | Level 1 | 5610 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.786419 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
710994 | TOF Footing | 8677 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0364583 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0375 | 0.0328084 | 0.0410105 | 0.0656168 | 0.082021 | 0.0234375 | 0.0729167 | 0.09375 | 25 mmø-20 mmø | 0.0410105 | 0.0410105
643375 | TOF Footing | 2719 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.460312 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
647709 | 1A13 | 3224 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.0396875 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
701330 | TOF Footing | 7499 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1002029 | Level 1 | 10207 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
1049926 | 2D15 | 12472 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1027843 | 1A07 | 11528 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
690997 | TOF Footing | 6355 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0364583 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0375 | 0.0328084 | 0.0410105 | 0.0656168 | 0.082021 | 0.0234375 | 0.0729167 | 0.09375 | 25 mmø-20 mmø | 0.0410105 | 0.0410105
1052030 | 2A11 | 13028 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1080544 | 1B10 | 14198 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.610319 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
1026115 | 1BC4 | 11079 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
657195 | 1B04 | 3613 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.260417 | 9.99787 | 0.0885417 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.62981 | 0.0708333 | 0.104167 | 0.082021 | 0.131234 | 0.164042 | 0.262467 | 0.0651042 | 0.177083 | 0.260417 | 80 mmø-50 mmø | 0.129105 | 0.131234
640200 | TOF Footing | 2342 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.34375 | 10 | 0.171875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.1375 | 0.0708333 | 0.164042 | 0.082021 | 0.328084 | 0.164042 | 0.0859375 | 0.34375 | 0.177083 | 100 mmø-50 mmø | 0.082021 | 0.082021
683655 | Level 1 | 5458 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.371263 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
687730 | TOF Footing | 5957 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0375 | 0.0708333 | 0.0410105 | 0.082021 | 0.082021 | 0.164042 | 0.0442708 | 0.09375 | 0.177083 | 50 mmø-25 mmø | 0.082021 | 0.082021
655603 | 1B07 | 3465 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.34375 | 10 | 0.0677083 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -0.345912 | 0.0541667 | 0.1375 | 0.0656168 | 0.164042 | 0.131234 | 0.328084 | 0.0859375 | 0.135417 | 0.34375 | 100 mmø-40 mmø | 0.164042 | 0.164042
1049820 | 2D10 | 12444 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
711263 | TOF Footing | 8733 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0260417 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0375 | 0.0246063 | 0.0410105 | 0.0492126 | 0.082021 | 0.0234375 | 0.0520833 | 0.09375 | 25 mmø-15 mmø | 0.0410105 | 0.0410105
1051499 | 2B3 | 12916 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.98518 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1110935 | 1CC3 | 15051 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
658328 | 1D20 | 3682 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.62311 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
1013148 | 1D21 | 10715 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
718619 | 1AC3 | 9431 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
701331 | TOF Footing | 7500 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1048254 | 2C19 | 12068 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
678531 | TOF Footing | 4958 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.046875 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0375 | 0.0541667 | 0.0410105 | 0.0656168 | 0.082021 | 0.131234 | 0.0338542 | 0.09375 | 0.135417 | 40 mmø-25 mmø | 0.0656168 | 0.0656168
697765 | 1D10 | 7097 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.0885417 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0708333 | 0.0875 | 0.082021 | 0.106627 | 0.164042 | 0.213255 | 0.0546875 | 0.177083 | 0.21875 | 65 mmø-50 mmø | 0.106627 | 0.106627
1002135 | 1DC6 | 10212 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
1078458 | 1D35 | 14037 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.610319 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
1000751 | 1EC1 | 10103 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
666178 | Level 1 | 4598 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
1028633 | 1C13 | 11685 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0188 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0844054 | 0.0656168
1013953 | 1D07 | 10971 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.017 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0825816 | 0.0656168
665880 | 1D02 | 4566 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
1049276 | 2D05 | 12304 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
656396 | 1D32 | 3531 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.260417 | 10 | 0.0572917 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.4 | 0.0458333 | 0.104167 | 0.0524934 | 0.131234 | 0.104987 | 0.262467 | 0.0651042 | 0.114583 | 0.260417 | 80 mmø-32 mmø | 0.131234 | 0.131234
686668 | 1A16 | 5822 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.343481 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
682681 | TOF Footing | 5376 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.0677083 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0541667 | 0.0875 | 0.0656168 | 0.106627 | 0.131234 | 0.213255 | 0.0546875 | 0.135417 | 0.21875 | 65 mmø-40 mmø | 0.106627 | 0.106627
683997 | TOF Footing | 5497 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
654024 | 1B04 | 3317 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.34375 | 10 | 0.0677083 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -0.411 | 0.0541667 | 0.1375 | 0.0656168 | 0.164042 | 0.131234 | 0.328084 | 0.0859375 | 0.135417 | 0.34375 | 100 mmø-40 mmø | 0.164042 | 0.164042
695197 | 1C10 | 6784 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1027449 | 1B01 | 11400 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1048324 | 2C19 | 12084 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1077946 | Level 1 | 13990 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.2 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
701104 | 1E09 | 7474 | Domestic Cold Water | Domestic Cold Water 1 | 10 | yes | no | no | 0.0729167 | 10 | 0.0364583 | 0.0260417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.2 | 0.0291667 | 0.0208333 | 0.0328084 | 0.0246063 | 0.0656168 | 0.0492126 | 0.0182292 | 0.0729167 | 0.0520833 | 20 mmø-15 mmø | 0.0246063 | 0.0246063
1051324 | 2D04 | 12856 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.9582 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0653066 | 0.0656168
709595 | TOF Footing | 8518 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.114583 | 10 | 0.0364583 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0458333 | 0.0328084 | 0.0524934 | 0.0656168 | 0.104987 | 0.0286458 | 0.0729167 | 0.114583 | 32 mmø-20 mmø | 0.0524934 | 0.0524934
1048958 | 2D05 | 12188 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
678403 | TOF Footing | 4946 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
685405 | TOF Footing | 5671 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1030195 | 2D18 | 11839 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
684941 | TOF Footing | 5625 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
577816 | TOF Footing | 99 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
719661 | 1DC3 | 9534 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1048288 | 2C19 | 12076 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
683554 | TOF Footing | 5435 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0572917 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0458333 | 0.1375 | 0.0524934 | 0.164042 | 0.104987 | 0.328084 | 0.0859375 | 0.114583 | 0.34375 | 100 mmø-32 mmø | 0.164042 | 0.164042
701200 | TOF Footing | 7498 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1000542 | Level 1 | 10092 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0364583 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0291667 | 0.0375 | 0.0328084 | 0.0410105 | 0.0656168 | 0.082021 | 0.0234375 | 0.0729167 | 0.09375 | 25 mmø-20 mmø | 0.0410105 | 0.0410105
701568 | TOF Footing | 7529 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0260417 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0375 | 0.0246063 | 0.0410105 | 0.0492126 | 0.082021 | 0.0234375 | 0.0520833 | 0.09375 | 25 mmø-15 mmø | 0.0410105 | 0.0410105
708873 | TOF Footing | 8440 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
712225 | 2B5 | 8843 | Domestic Hot Water | Domestic Hot Water 1 | 10 | yes | no | no | 0.0729167 | 10 | 0.0364583 | 0.0260417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.3 | 0.0291667 | 0.0208333 | 0.0328084 | 0.0246063 | 0.0656168 | 0.0492126 | 0.0182292 | 0.0729167 | 0.0520833 | 20 mmø-15 mmø | 0.0246063 | 0.0246063
647577 | Level 1 | 3208 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.29802 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
709394 | TOF Footing | 8499 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
712687 | 1B03 | 8867 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0364583 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0291667 | 0.0375 | 0.0328084 | 0.0410105 | 0.0656168 | 0.082021 | 0.0234375 | 0.0729167 | 0.09375 | 25 mmø-20 mmø | 0.0410105 | 0.0410105
689754 | TOF Footing | 6201 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1052117 | 2A14 | 13048 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
694967 | 1C02 | 6750 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
697357 | 1A05 | 7034 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
686520 | TOF Footing | 5808 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
637643 | TOF Footing | 2058 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.177083 | 10 | 0.0885417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.501123 | 0.0708333 | 0.0458333 | 0.082021 | 0.0524934 | 0.164042 | 0.104987 | 0.0442708 | 0.177083 | 0.114583 | 50 mmø-32 mmø | 0.0524934 | 0.0524934
1050380 | 2BC4 | 12600 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
