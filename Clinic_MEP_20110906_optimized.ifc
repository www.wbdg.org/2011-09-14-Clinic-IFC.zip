Properties of the parts of a building model (IFC2X3), part 34 of 295

# IfcFlowFitting: Tee - Generic (921)
Name (M_Tee - Generic:Tee - Generic:Tee - Generic:...) | In | Center to End Label | Fitting Outside Radius = Insulation Radius | Angle 1 (deg) | Tick Size | Nominal Radius | Nominal Diameter | Fitting Outside Diameter | Center to End | Angle (deg) | Size | System Type | System Name | Mark | Level | Host | Offset (m)
659023 | 2C12 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 3764 | Level 2 | Level : Level 2 | 2.9
682784 | Level 1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5390 | Level 1 | Level : Level 1 | 0.371263
703889 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7823 | Level 1 | Level : Level 1 | -0.3
691187 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6394 | Level 1 | Level : Level 1 | -0.4
1048779 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12121 | Level 2 | Level : Level 2 | 2.985
683550 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 5432 | Level 1 | Level : Level 1 | -0.5
1027529 | 1AC2 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11417 | Level 1 | Level : Level 1 | 2.985
1049272 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12301 | Level 2 | Level : Level 2 | 2.985
687695 | TOF Footing | 0.213542 | 0.171875 | 89.9997 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90.0003 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 5950 | Level 1 | Level : Level 1 | -0.501123
1013232 | 1D17 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10740 | Level 1 | Level : Level 1 | 2.985
1001163 | 1E24 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10132 | Level 1 | Level : Level 1 | 2.985
666373 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4627 | Level 1 | Level : Level 1 | -0.5
708232 | Level 1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Cold Water | Domestic Cold Water 1 | 8351 | Level 1 | Level : Level 1 | 0.688244
1027576 | 1A14 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11441 | Level 1 | Level : Level 1 | 2.985
1048020 | 2C08 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12009 | Level 2 | Level : Level 2 | 2.985
1027636 | 1A16 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11461 | Level 1 | Level : Level 1 | 2.985
681811 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5285 | Level 1 | Level : Level 1 | -0.4
680182 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5108 | Level 1 | Level : Level 1 | -0.4
658386 | 1D18 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3689 | Level 2 | Level : Level 2 | -1.6882
659065 | 1D13 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3768 | Level 2 | Level : Level 2 | -1.6882
681231 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 5195 | Level 1 | Level : Level 1 | -0.5
667503 | 1D01 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4786 | Level 2 | Level : Level 2 | -1.56
644021 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2788 | Level 1 | Level : Level 1 | -0.5
695097 | 1C10 | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6771 | Level 2 | Level : Level 2 | -1.5
1052059 | 2A14 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13033 | Level 2 | Level : Level 2 | 2.985
659152 | Level 1 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3781 | Level 2 | Level : Level 2 | -1.6882
1048115 | 2C12 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12033 | Level 2 | Level : Level 2 | 2.985
648403 | 1D06 | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Sanitary | Sanitary 1 | 3273 | Level 1 | Level : Level 1 | 0
687758 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5958 | Level 1 | Level : Level 1 | -0.4
577811 | TOF Footing | 0.415597 | 0.171875 | 44.9363 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 44.9363 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 96 | Level 1 | Level : Level 1 | -0.5
662867 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4257 | Level 2 | Level : Level 2 | 3
685454 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5672 | Level 1 | Level : Level 1 | -0.4
1076257 | Level 1 | 0.0677083 | 0.0260417 | 90 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0520833 | 0.0677083 | 90 | 15 mmø-15 mmø-15 mmø | Domestic Cold Water | Domestic Cold Water 1 | 13870 | Level 1 | Level : Level 1 | 0.806263
666923 | 1DC3 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 4715 | Level 2 | Level : Level 2 | -1.56
725458 | 1B01 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Storm | 9864 | Level 2 | Level : Level 2 | -0.444
654514 | Level 1 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 3362 | Level 2 | Level : Level 2 | -0.411
658064 | Level 1 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3658 | Level 2 | Level : Level 2 | -1.6882
686871 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5850 | Level 1 | Level : Level 1 | -0.4
1030150 | 2D14 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 11830 | Level 2 | Level : Level 2 | 2.985
679022 | TOF Footing | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Cold Water | Domestic Cold Water 1 | 4984 | Level 1 | Level : Level 1 | -0.4
1029377 | 2A11 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11746 | Level 2 | Level : Level 2 | 2.985
648146 | Level 1 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3256 | Level 1 | Level : Level 1 | 0
1001737 | 1D40 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10174 | Level 1 | Level : Level 1 | 2.985
705375 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7994 | Level 1 | Level : Level 1 | -0.25
687994 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5994 | Level 1 | Level : Level 1 | -0.4
698455 | Level 2 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7167 | Level 2 | Level : Level 2 | 0.7
656448 | TOF Footing | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 3534 | Level 1 | Level : Level 1 | -0.5
667401 | Level 2 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 4775 | Level 2 | Level : Level 2 | 1
1000730 | 1EC1 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10096 | Level 1 | Level : Level 1 | 2.985
662409 | 2A09 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4205 | Level 2 | Level : Level 2 | 2.9
1029665 | 2BC2 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 11772 | Level 2 | Level : Level 2 | 2.98519
1048812 | 2CC1 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12137 | Level 2 | Level : Level 2 | 2.985
1047583 | 2CC4 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11937 | Level 2 | Level : Level 2 | 2.985
1029687 | 2BC2 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 11776 | Level 2 | Level : Level 2 | 2.98519
695250 | 1C07 | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6789 | Level 2 | Level : Level 2 | -1.5
700408 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7403 | Level 1 | Level : Level 1 | -0.35
660721 | 1CC1 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3952 | Level 2 | Level : Level 2 | -1.6882
1028540 | 1A12 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11654 | Level 1 | Level : Level 1 | 2.985
665041 | 1DC3 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4497 | Level 2 | Level : Level 2 | -1.6882
644908 | Level 1 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2866 | Level 1 | Level : Level 1 | 0.232932
662557 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4221 | Level 1 | Level : Level 1 | -0.5
1049006 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12205 | Level 2 | Level : Level 2 | 2.985
690503 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6292 | Level 1 | Level : Level 1 | -0.4
690659 | TOF Footing | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6315 | Level 1 | Level : Level 1 | -0.4
660016 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 3867 | Level 2 | Level : Level 2 | 3
678460 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 4951 | Level 1 | Level : Level 1 | -0.4
665117 | Level 2 | 0.171272 | 0.0677083 | 43.1403 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 43.1403 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 4506 | Level 2 | Level : Level 2 | 3.1
654020 | 1B04 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 3314 | Level 2 | Level : Level 2 | -0.411
644755 | Level 1 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 2847 | Level 1 | Level : Level 1 | 0.3
685633 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5693 | Level 1 | Level : Level 1 | -0.4
666624 | Level 2 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4661 | Level 2 | Level : Level 2 | 0.2
657191 | 1B04 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Default Sanitary (cskender) | 3610 | Level 2 | Level : Level 2 | -1.6822
688352 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6037 | Level 1 | Level : Level 1 | -0.4
656798 | TOF Footing | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 3568 | Level 1 | Level : Level 1 | -0.3
682101 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5309 | Level 1 | Level : Level 1 | -0.4
660648 | 1CC1 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3934 | Level 2 | Level : Level 2 | -1.6882
1048091 | 2C10 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12025 | Level 2 | Level : Level 2 | 2.985
655688 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3474 | Level 1 | Level : Level 1 | -0.5
653819 | 1B08 | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Sanitary | Default Sanitary (cskender) | 3297 | Level 2 | Level : Level 2 | -0.411
655124 | Level 1 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 3403 | Level 1 | Level : Level 1 | 0
1029290 | 2A03 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11740 | Level 2 | Level : Level 2 | 2.985
1049087 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12229 | Level 2 | Level : Level 2 | 2.985
661305 | Level 2 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 4046 | Level 2 | Level : Level 2 | 0.2
688652 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6071 | Level 1 | Level : Level 1 | -0.4
656058 | Level 2 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3503 | Level 2 | Level : Level 2 | 1
1027742 | 1AC5 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11497 | Level 1 | Level : Level 1 | 2.985
1056712 | 1D20 | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 13428 | Level 2 | Level : Level 2 | -1.5
692189 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6475 | Level 2 | Level : Level 2 | 0.2
665909 | 1D02 | 0.213758 | 0.0885417 | 45 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 45 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4568 | Level 2 | Level : Level 2 | -1.6882
1051450 | 2B7 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12901 | Level 2 | Level : Level 2 | 2.98518
1030057 | 2BC2 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 11810 | Level 2 | Level : Level 2 | 2.98519
662671 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4237 | Level 2 | Level : Level 2 | 0.2
1050715 | 2DC1 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12693 | Level 2 | Level : Level 2 | 2.98499
1009804 | 1DC4 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10483 | Level 1 | Level : Level 1 | 2.985
1053077 | 2BC5 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13323 | Level 2 | Level : Level 2 | 2.985
701352 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7503 | Level 1 | Level : Level 1 | -0.3
1050456 | 2B15 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12621 | Level 2 | Level : Level 2 | 2.985
698525 | 1DC3 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7182 | Level 2 | Level : Level 2 | -1.5
683561 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5436 | Level 1 | Level : Level 1 | -0.4
718438 | 1D05 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9407 | Level 2 | Level : Level 2 | -1.4
1049886 | 2D16 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12461 | Level 2 | Level : Level 2 | 2.985
687800 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5963 | Level 1 | Level : Level 1 | -0.4
661154 | 1CC1 | 0.314351 | 0.130208 | 45 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 135 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 4023 | Level 2 | Level : Level 2 | -1.6882
664262 | Level 1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 4379 | Level 1 | Level : Level 1 | 3.17
718668 | 1A12 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9433 | Level 2 | Level : Level 2 | -1.4
665707 | Level 2 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 4554 | Level 2 | Level : Level 2 | 2.9
655599 | 1B07 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 3462 | Level 2 | Level : Level 2 | -0.411
997990 | Level 2 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.082021 | 0.164042 | 0.09375 | 0.0885417 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 10009 | Level 2 | Level : Level 2 | 0.2
1030134 | 2D15 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 11826 | Level 2 | Level : Level 2 | 2.985
691510 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6441 | Level 1 | Level : Level 1 | -0.4
1050510 | 2B13 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12637 | Level 2 | Level : Level 2 | 2.985
1027545 | 1A15 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11425 | Level 1 | Level : Level 1 | 2.985
1051337 | 2D03 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12861 | Level 2 | Level : Level 2 | 2.98518
666768 | 2C07 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 4687 | Level 2 | Level : Level 2 | 2.9
697660 | 1C02 | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7074 | Level 2 | Level : Level 2 | -1.5
1007541 | 1DC6 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10421 | Level 1 | Level : Level 1 | 2.985
1048794 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12129 | Level 2 | Level : Level 2 | 2.985
697353 | 1A05 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7031 | Level 2 | Level : Level 2 | -1.5
658032 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3656 | Level 1 | Level : Level 1 | -0.5
1049257 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12293 | Level 2 | Level : Level 2 | 2.985
1052308 | 2AC1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13082 | Level 2 | Level : Level 2 | 2.985
637194 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1984 | Level 1 | Level : Level 1 | -0.501123
1026976 | 1B10 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11257 | Level 1 | Level : Level 1 | 2.985
684450 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5553 | Level 1 | Level : Level 1 | -0.4
664313 | 1D07 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 4397 | Level 2 | Level : Level 2 | -1.6882
1050058 | 2BC2 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12497 | Level 2 | Level : Level 2 | 2.985
680335 | Level 1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5131 | Level 1 | Level : Level 1 | 0.371263
655429 | 1B07 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 3434 | Level 2 | Level : Level 2 | -0.411
689252 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6160 | Level 1 | Level : Level 1 | -0.4
1050024 | 2D20 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12489 | Level 2 | Level : Level 2 | 2.985
688520 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6060 | Level 1 | Level : Level 1 | -0.4
686952 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5861 | Level 1 | Level : Level 1 | -0.4
709298 | TOF Footing | 0.0677083 | 0.0260417 | 90 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0520833 | 0.0677083 | 90 | 15 mmø-15 mmø-15 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8493 | Level 1 | Level : Level 1 | -0.3
1028644 | 1C15 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11690 | Level 1 | Level : Level 1 | 2.985
1050201 | 2B18 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12549 | Level 2 | Level : Level 2 | 2.985
633294 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1411 | Level 1 | Level : Level 1 | -0.5
1001312 | Level 1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10141 | Level 1 | Level : Level 1 | 2.985
1051434 | 2B9 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12893 | Level 2 | Level : Level 2 | 2.98518
691915 | 1B09 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6448 | Level 1 | Level : Level 1 | 3.07
1048320 | 2C19 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12081 | Level 2 | Level : Level 2 | 2.985
662688 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4240 | Level 2 | Level : Level 2 | 0.5
1048836 | 2C08 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12145 | Level 2 | Level : Level 2 | 2.985
646429 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 3078 | Level 1 | Level : Level 1 | -0.501123
1050773 | 2B12 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12717 | Level 2 | Level : Level 2 | 2.985
1051466 | 2B4 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12909 | Level 2 | Level : Level 2 | 2.98518
1047812 | 2CC5 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11969 | Level 2 | Level : Level 2 | 2.985
1051353 | 2BC1 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12869 | Level 2 | Level : Level 2 | 2.98518
698922 | 1D08 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7237 | Level 2 | Level : Level 2 | -1.5
680540 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5152 | Level 1 | Level : Level 1 | -0.4
1001688 | 1B15 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10169 | Level 1 | Level : Level 1 | 2.985
1001704 | 1BC1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10171 | Level 1 | Level : Level 1 | 2.985
658540 | Level 1 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3712 | Level 2 | Level : Level 2 | -1.6882
655985 | Level 2 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3500 | Level 2 | Level : Level 2 | 0.232932
678730 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 4962 | Level 1 | Level : Level 1 | -0.4
654238 | Level 2 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Default Sanitary (cskender) | 3337 | Level 2 | Level : Level 2 | 1
680661 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5171 | Level 1 | Level : Level 1 | -0.4
679349 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5018 | Level 1 | Level : Level 1 | -0.4
1013421 | 1C03 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10812 | Level 1 | Level : Level 1 | 2.985
1051807 | 2C24 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12973 | Level 2 | Level : Level 2 | 2.985
1001449 | 1BC4 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10150 | Level 1 | Level : Level 1 | 2.985
662633 | 1A16 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4229 | Level 2 | Level : Level 2 | -1.6882
717588 | 1C07 | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9355 | Level 2 | Level : Level 2 | -1.4
1001771 | 1DC7 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10178 | Level 1 | Level : Level 1 | 2.985
1030100 | 2D19 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 11818 | Level 2 | Level : Level 2 | 2.985
677787 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Domestic Cold Water | Domestic Cold Water 1 | 4914 | Level 1 | Level : Level 1 | -0.4
654458 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 3357 | Level 1 | Level : Level 1 | -0.5
686590 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5813 | Level 1 | Level : Level 1 | -0.4
647786 | Level 1 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 3233 | Level 1 | Level : Level 1 | 1
1026960 | 1B12 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11249 | Level 1 | Level : Level 1 | 2.985
716381 | 1C15 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9235 | Level 2 | Level : Level 2 | -1.4
1026991 | 1B08 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11265 | Level 1 | Level : Level 1 | 2.985
1052938 | 2D18 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13259 | Level 2 | Level : Level 2 | 2.985
689379 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6171 | Level 1 | Level : Level 1 | -0.4
1028519 | 1AC2 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11643 | Level 1 | Level : Level 1 | 2.985
1026914 | 1BC3 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11225 | Level 1 | Level : Level 1 | 2.985
705097 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7950 | Level 1 | Level : Level 1 | -0.25
699419 | 1D16 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 7293 | Level 2 | Level : Level 2 | -1.6882
1051925 | 2C01 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13001 | Level 2 | Level : Level 2 | 2.985
1005133 | 1EC1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10410 | Level 1 | Level : Level 1 | 2.985
706301 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8085 | Level 1 | Level : Level 1 | -0.3
698700 | 1D07 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 7193 | Level 2 | Level : Level 2 | -1.56
1052893 | 2A01 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13247 | Level 2 | Level : Level 2 | 2.985
1027620 | 1A16 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11453 | Level 1 | Level : Level 1 | 2.985
654832 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Default Sanitary (cskender) | 3382 | Level 2 | Level : Level 2 | 2.9
1027205 | 1B09 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11333 | Level 1 | Level : Level 1 | 2.985
633455 | TOF Footing | 0.350984 | 0.171875 | 52.1815 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 127.819 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1427 | Level 1 | Level : Level 1 | -0.5
1026111 | 1BC4 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 11076 | Level 1 | Level : Level 1 | 2.985
1050825 | 2B8 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12733 | Level 2 | Level : Level 2 | 2.985
1027930 | 1DC6 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11553 | Level 1 | Level : Level 1 | 2.985
666181 | 2C23 | 0.163462 | 0.0677083 | 45 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 135 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 4601 | Level 2 | Level : Level 2 | 2.9
701100 | Level 1 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7471 | Level 1 | Level : Level 1 | 0.2
684612 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5571 | Level 1 | Level : Level 1 | -0.4
689020 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6128 | Level 1 | Level : Level 1 | -0.4
644956 | Level 1 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2881 | Level 1 | Level : Level 1 | 0.6
1027560 | 1A16 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11433 | Level 1 | Level : Level 1 | 2.985
669562 | 1D27 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4795 | Level 2 | Level : Level 2 | -1.6882
1026882 | 1BC4 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11209 | Level 1 | Level : Level 1 | 2.985
698135 | 1D10 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7119 | Level 2 | Level : Level 2 | -1.5
699129 | 1C15 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7279 | Level 2 | Level : Level 2 | -1.5
661268 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4040 | Level 2 | Level : Level 2 | 0.2
692210 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6485 | Level 2 | Level : Level 2 | 0.2
1048988 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12197 | Level 2 | Level : Level 2 | 2.985
717868 | 1C07 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9390 | Level 2 | Level : Level 2 | -1.4
1030027 | 2BC2 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 11806 | Level 2 | Level : Level 2 | 2.98519
1050799 | 2B10 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12725 | Level 2 | Level : Level 2 | 2.985
665228 | Level 1 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4524 | Level 2 | Level : Level 2 | -1.6882
1013199 | 1DC4 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10728 | Level 1 | Level : Level 1 | 2.985
1049290 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12309 | Level 2 | Level : Level 2 | 2.985
1028026 | 1D12 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11589 | Level 1 | Level : Level 1 | 2.985
698939 | Level 2 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7243 | Level 2 | Level : Level 2 | 0.2
1053307 | 2AC4 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13375 | Level 2 | Level : Level 2 | 2.985
636814 | TOF Footing | 0.297698 | 0.171875 | 59.9997 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 120 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1945 | Level 1 | Level : Level 1 | -0.5
1049463 | 2D07 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12365 | Level 2 | Level : Level 2 | 2.985
683826 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5465 | Level 1 | Level : Level 1 | -0.4
1001262 | 1B04 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10138 | Level 1 | Level : Level 1 | 2.985
1000747 | 1EC1 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10100 | Level 1 | Level : Level 1 | 2.985
688128 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6008 | Level 1 | Level : Level 1 | -0.4
656945 | Level 1 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 3579 | Level 1 | Level : Level 1 | 0
697677 | 1D12 | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7075 | Level 2 | Level : Level 2 | -1.5
1001762 | 1DC7 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10176 | Level 1 | Level : Level 1 | 2.985
1052863 | 2A02 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13231 | Level 2 | Level : Level 2 | 2.985
701114 | Level 1 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7475 | Level 1 | Level : Level 1 | 0.2
709591 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8515 | Level 1 | Level : Level 1 | -0.3
1052572 | 2AC3 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13155 | Level 2 | Level : Level 2 | 2.985
644183 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2814 | Level 1 | Level : Level 1 | -0.5
701905 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7564 | Level 1 | Level : Level 1 | -0.4
1030178 | 2D16 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 11834 | Level 2 | Level : Level 2 | 2.985
647036 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3148 | Level 1 | Level : Level 1 | -0.501123
644203 | TOF Footing | 0.532656 | 0.171875 | 35.7673 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 35.7673 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2824 | Level 1 | Level : Level 1 | -0.501123
641158 | TOF Footing | 0.163462 | 0.0677083 | 45 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 45 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 2423 | Level 1 | Level : Level 1 | -0.3
686720 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5828 | Level 1 | Level : Level 1 | -0.4
646584 | TOF Footing | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 3107 | Level 1 | Level : Level 1 | -0.3
1013109 | 1D19 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10700 | Level 1 | Level : Level 1 | 2.985
665451 | Level 2 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 4549 | Level 2 | Level : Level 2 | 3.1
690271 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6273 | Level 1 | Level : Level 1 | -0.4
684839 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5603 | Level 1 | Level : Level 1 | -0.4
1013949 | 1D07 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10968 | Level 1 | Level : Level 1 | 2.985
1048391 | 2C08 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12097 | Level 2 | Level : Level 2 | 2.985
685173 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5656 | Level 1 | Level : Level 1 | -0.4
1049021 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12213 | Level 2 | Level : Level 2 | 2.985
660382 | 1DC4 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3913 | Level 2 | Level : Level 2 | -1.6882
1030006 | 2BC2 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 11802 | Level 2 | Level : Level 2 | 2.98518
1008146 | 1DC1 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10455 | Level 1 | Level : Level 1 | 2.985
1049102 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12237 | Level 2 | Level : Level 2 | 2.985
718999 | 1A16 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9469 | Level 2 | Level : Level 2 | -1.4
684792 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5593 | Level 1 | Level : Level 1 | -0.4
644781 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2856 | Level 1 | Level : Level 1 | -0.501123
1026945 | 1B14 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11241 | Level 1 | Level : Level 1 | 2.985
1053047 | 2BC5 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13307 | Level 2 | Level : Level 2 | 2.985
661049 | 2C14 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4005 | Level 2 | Level : Level 2 | 0.2
700901 | Level 1 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7456 | Level 1 | Level : Level 1 | 0.3
1028928 | 2BC2 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 11708 | Level 2 | Level : Level 2 | 2.98519
1001532 | 1BC4 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10160 | Level 1 | Level : Level 1 | 2.985
1001921 | 1EC1 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10199 | Level 1 | Level : Level 1 | 2.985
708797 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8435 | Level 1 | Level : Level 1 | -0.3
1053128 | 2A11 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13335 | Level 2 | Level : Level 2 | 2.985
683397 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 5407 | Level 1 | Level : Level 1 | -0.5
641151 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2417 | Level 1 | Level : Level 1 | -0.5
1008304 | 1DC1 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10475 | Level 1 | Level : Level 1 | 2.985
664621 | 2AC2 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 4460 | Level 2 | Level : Level 2 | 2.9
664911 | 1D05 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4474 | Level 2 | Level : Level 2 | -1.6882
1053162 | 2AC5 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13343 | Level 2 | Level : Level 2 | 2.985
664142 | 1D05 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4362 | Level 2 | Level : Level 2 | -1.6882
633632 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1448 | Level 1 | Level : Level 1 | -0.5
661949 | 1A09 | 0.314351 | 0.130208 | 45 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 45 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 4129 | Level 2 | Level : Level 2 | -1.6882
688667 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6076 | Level 1 | Level : Level 1 | -0.4
1027082 | 1BC2 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11297 | Level 1 | Level : Level 1 | 2.985
657991 | 1D27 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3649 | Level 2 | Level : Level 2 | -1.6882
1052284 | 2BC1 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 13078 | Level 2 | Level : Level 2 | 2.98518
1013247 | 1D16 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10748 | Level 1 | Level : Level 1 | 2.985
1008021 | 1C07 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10449 | Level 1 | Level : Level 1 | 2.985
711131 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8704 | Level 1 | Level : Level 1 | -0.3
655520 | 1B05 | 0.15548 | 0.0885417 | 59.3208 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 59.3208 | 50 mmø-50 mmø-50 mmø | Sanitary | Default Sanitary (cskender) | 3454 | Level 2 | Level : Level 2 | -0.2
1002938 | 1A12 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10298 | Level 1 | Level : Level 1 | 2.985
1002270 | 1BC4 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10220 | Level 1 | Level : Level 1 | 2.985
1050852 | 2B25 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12741 | Level 2 | Level : Level 2 | 2.985
643231 | TOF Footing | 0.213758 | 0.0885417 | 45 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 135 | 50 mmø-50 mmø-50 mmø | Sanitary | Default Sanitary (cskender) | 2702 | Level 1 | Level : Level 1 | -0.5
1052093 | 2A14 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13041 | Level 2 | Level : Level 2 | 2.985
1005085 | 1E17 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10386 | Level 1 | Level : Level 1 | 2.985
1030118 | 2D17 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 11822 | Level 2 | Level : Level 2 | 2.985
1050537 | 2BC2 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12645 | Level 2 | Level : Level 2 | 2.985
643371 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Default Sanitary (cskender) | 2716 | Level 1 | Level : Level 1 | -0.5
666805 | 1DC3 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4694 | Level 2 | Level : Level 2 | -1.56
688853 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6101 | Level 1 | Level : Level 1 | -0.4
1053002 | 2BC6 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13291 | Level 2 | Level : Level 2 | 2.985
