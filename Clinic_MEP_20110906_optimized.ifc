Properties of the parts of a building model (IFC2X3), part 38 of 295

# IfcFlowFitting: Transition - Generic (1536)
Name (M_Transition - Generic:Transition - Generic:Transition - Generic:...) | In | Mark | System Type | System Name | Width Offset | Visibility 3 | Visibility 2 | Visibility 1 | Max Fitting Outside Diameter 12 | Height Offset | Fitting Outside Radius 2 = Insulation Radius 2 | Fitting Outside Radius 1 = Insulation Radius 1 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level | Host | Offset (m) | Tick Size 2 | Tick Size 1 | Nominal Radius 2 | Nominal Radius 1 | Nominal Diameter 2 | Nominal Diameter 1 | Length | Fitting Outside Diameter 2 | Fitting Outside Diameter 1 | Size | OffsetHeight | OffsetWidth
687916 | TOF Footing | 5981 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.0364583 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0875 | 0.0328084 | 0.106627 | 0.0656168 | 0.213255 | 0.0546875 | 0.0729167 | 0.21875 | 65 mmø-20 mmø | 0.106627 | 0.106627
718543 | 1AC3 | 9419 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0260417 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0375 | 0.0246063 | 0.0410105 | 0.0492126 | 0.082021 | 0.0234375 | 0.0520833 | 0.09375 | 25 mmø-15 mmø | 0.0410105 | 0.0410105
688110 | TOF Footing | 6007 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
644912 | Level 1 | 2869 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.29802 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
1027624 | 1A16 | 11456 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0135 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.07914 | 0.0656168
679765 | TOF Footing | 5068 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
685586 | TOF Footing | 5691 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
654323 | 1B08 | 3347 | Sanitary | Default Sanitary (cskender) | 10 | yes | no | no | 0.260417 | 10 | 0.130208 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -0.411 | 0.104167 | 0.0458333 | 0.131234 | 0.0524934 | 0.262467 | 0.104987 | 0.0651042 | 0.260417 | 0.114583 | 80 mmø-32 mmø | 0.0524934 | 0.0524934
633047 | TOF Footing | 1379 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0572917 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.241263 | 0.0458333 | 0.1375 | 0.0524934 | 0.164042 | 0.104987 | 0.328084 | 0.0859375 | 0.114583 | 0.34375 | 100 mmø-32 mmø | 0.164042 | 0.164042
1048931 | 2D05 | 12176 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1032619 | 2AC2 | 11902 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
689024 | TOF Footing | 6131 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0677083 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0541667 | 0.1375 | 0.0656168 | 0.164042 | 0.131234 | 0.328084 | 0.0859375 | 0.135417 | 0.34375 | 100 mmø-40 mmø | 0.164042 | 0.164042
1048949 | 2D05 | 12184 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1052882 | 2A01 | 13242 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1004795 | 1E28 | 10320 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
646050 | TOF Footing | 3004 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0572917 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.434912 | 0.0458333 | 0.1375 | 0.0524934 | 0.164042 | 0.104987 | 0.328084 | 0.0859375 | 0.114583 | 0.34375 | 100 mmø-32 mmø | 0.164042 | 0.164042
701159 | Level 1 | 7491 | Domestic Cold Water | Domestic Cold Water 1 | 10 | yes | no | no | 0.09375 | 10 | 0.046875 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.217462 | 0.0375 | 0.0291667 | 0.0410105 | 0.0328084 | 0.082021 | 0.0656168 | 0.0234375 | 0.09375 | 0.0729167 | 25 mmø-20 mmø | 0.0328084 | 0.0328084
708975 | TOF Footing | 8453 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
664146 | 1D05 | 4365 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.130208 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.104167 | 0.1375 | 0.131234 | 0.164042 | 0.262467 | 0.328084 | 0.0859375 | 0.260417 | 0.34375 | 100 mmø-80 mmø | 0.164042 | 0.164042
688656 | TOF Footing | 6074 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0364583 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.1375 | 0.0328084 | 0.164042 | 0.0656168 | 0.328084 | 0.0859375 | 0.0729167 | 0.34375 | 100 mmø-20 mmø | 0.164042 | 0.164042
666824 | 1DC3 | 4703 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.260417 | 10 | 0.130208 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.56 | 0.104167 | 0.0375 | 0.131234 | 0.0410105 | 0.262467 | 0.082021 | 0.0651042 | 0.260417 | 0.09375 | 80 mmø-25 mmø | 0.0410105 | 0.0410105
659246 | 1D16 | 3797 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.260417 | 10 | 0.0885417 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.0708333 | 0.104167 | 0.082021 | 0.131234 | 0.164042 | 0.262467 | 0.0651042 | 0.177083 | 0.260417 | 80 mmø-50 mmø | 0.131234 | 0.131234
686501 | TOF Footing | 5802 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.0885417 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0708333 | 0.0875 | 0.082021 | 0.106627 | 0.164042 | 0.213255 | 0.0546875 | 0.177083 | 0.21875 | 65 mmø-50 mmø | 0.106627 | 0.106627
662522 | Level 1 | 4217 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.130208 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.104167 | 0.1375 | 0.131234 | 0.164042 | 0.262467 | 0.328084 | 0.0859375 | 0.260417 | 0.34375 | 100 mmø-80 mmø | 0.164042 | 0.164042
1050404 | 2B19 | 12608 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
666623 | 2C08 | 4660 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.34375 | 10 | 0.171875 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.2 | 0.1375 | 0.0458333 | 0.164042 | 0.0524934 | 0.328084 | 0.104987 | 0.0859375 | 0.34375 | 0.114583 | 100 mmø-32 mmø | 0.0524934 | 0.0524934
648100 | 1C09 | 3251 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.0333375 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
680339 | Level 1 | 5134 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.371263 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
684111 | TOF Footing | 5513 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
708976 | TOF Footing | 8454 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
678992 | TOF Footing | 4980 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0375 | 0.0708333 | 0.0410105 | 0.082021 | 0.082021 | 0.164042 | 0.0442708 | 0.09375 | 0.177083 | 50 mmø-25 mmø | 0.082021 | 0.082021
682788 | Level 1 | 5393 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.371263 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
647249 | TOF Footing | 3170 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0677083 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0541667 | 0.1375 | 0.0656168 | 0.164042 | 0.131234 | 0.328084 | 0.0859375 | 0.135417 | 0.34375 | 100 mmø-40 mmø | 0.164042 | 0.164042
632946 | TOF Footing | 1278 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.130208 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.104167 | 0.1375 | 0.131234 | 0.164042 | 0.262467 | 0.328084 | 0.0859375 | 0.260417 | 0.34375 | 100 mmø-80 mmø | 0.164042 | 0.164042
681508 | Level 1 | 5248 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0260417 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.784831 | 0.0208333 | 0.0375 | 0.0246063 | 0.0410105 | 0.0492126 | 0.082021 | 0.0234375 | 0.0520833 | 0.09375 | 25 mmø-15 mmø | 0.0410105 | 0.0410105
701143 | Level 1 | 7483 | Domestic Cold Water | Domestic Cold Water 1 | 10 | yes | no | no | 0.09375 | 10 | 0.046875 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.217462 | 0.0375 | 0.0291667 | 0.0410105 | 0.0328084 | 0.082021 | 0.0656168 | 0.0234375 | 0.09375 | 0.0729167 | 25 mmø-20 mmø | 0.0328084 | 0.0328084
684940 | TOF Footing | 5624 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1027934 | 1DC6 | 11556 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 9.97662 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0422367 | 0.0656168
1056716 | 1D20 | 13431 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.0364583 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.45396 | 0.0291667 | 0.0875 | 0.0328084 | 0.106627 | 0.0656168 | 0.213255 | 0.0546875 | 0.0729167 | 0.21875 | 65 mmø-20 mmø | 0.106627 | 0.106627
664487 | 2C24 | 4437 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.177083 | 10 | 0.0885417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.2 | 0.0708333 | 0.0458333 | 0.082021 | 0.0524934 | 0.164042 | 0.104987 | 0.0442708 | 0.177083 | 0.114583 | 50 mmø-32 mmø | 0.0524934 | 0.0524934
1004980 | 1E22 | 10344 | Fire Protection Wet | Fire Protection | 9.99836 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0639718
1001506 | 1BC4 | 10159 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
681793 | TOF Footing | 5284 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1030254 | 2D07 | 11845 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
660106 | Level 1 | 3887 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.130208 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.104167 | 0.1375 | 0.131234 | 0.164042 | 0.262467 | 0.328084 | 0.0859375 | 0.260417 | 0.34375 | 100 mmø-80 mmø | 0.164042 | 0.164042
662894 | Level 2 | 4268 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 9.9787 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95952 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.0607222 | 0.082021
657002 | Level 1 | 3594 | Sanitary | Default Sanitary (cskender) | 10 | yes | no | no | 0.34375 | 10 | 0.171875 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.72824 | 0.1375 | 0.104167 | 0.164042 | 0.131234 | 0.328084 | 0.262467 | 0.0859375 | 0.34375 | 0.260417 | 100 mmø-80 mmø | 0.131234 | 0.131234
692214 | Level 2 | 6488 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.2 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
688240 | TOF Footing | 6019 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1029669 | 2BC2 | 11775 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
685458 | TOF Footing | 5675 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0677083 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0541667 | 0.1375 | 0.0656168 | 0.164042 | 0.131234 | 0.328084 | 0.0859375 | 0.135417 | 0.34375 | 100 mmø-40 mmø | 0.164042 | 0.164042
1028648 | 1C15 | 11693 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0188 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0844054 | 0.0656168
718787 | 1A12 | 9450 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1048144 | 2C15 | 12044 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
660248 | 2C15 | 3897 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.177083 | 10 | 0.0885417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 3 | 0.0708333 | 0.0541667 | 0.082021 | 0.0656168 | 0.164042 | 0.131234 | 0.0442708 | 0.177083 | 0.135417 | 50 mmø-40 mmø | 0.0656168 | 0.0656168
1008260 | 1DC1 | 10474 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
695196 | 1C10 | 6783 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
688827 | TOF Footing | 6099 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
662128 | 1A16 | 4164 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.260417 | 10 | 0.0885417 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.0708333 | 0.104167 | 0.082021 | 0.131234 | 0.164042 | 0.262467 | 0.0651042 | 0.177083 | 0.260417 | 80 mmø-50 mmø | 0.131234 | 0.131234
1027859 | 1A05 | 11536 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0233 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0888742 | 0.0656168
666703 | Level 2 | 4681 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.135417 | 10 | 0.0677083 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 7.47 | 0.0541667 | 0.0458333 | 0.0656168 | 0.0524934 | 0.131234 | 0.104987 | 0.0338542 | 0.135417 | 0.114583 | 40 mmø-32 mmø | 0.0524934 | 0.0524934
681612 | TOF Footing | 5264 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0375 | 0.0708333 | 0.0410105 | 0.082021 | 0.082021 | 0.164042 | 0.0442708 | 0.09375 | 0.177083 | 50 mmø-25 mmø | 0.082021 | 0.082021
693527 | Level 2 | 6628 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.046875 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.3 | 0.0375 | 0.0541667 | 0.0410105 | 0.0656168 | 0.082021 | 0.131234 | 0.0338542 | 0.09375 | 0.135417 | 40 mmø-25 mmø | 0.0656168 | 0.0656168
1001536 | 1BC4 | 10163 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
662871 | Level 2 | 4260 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 3 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
708621 | TOF Footing | 8410 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
681611 | TOF Footing | 5263 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0375 | 0.0708333 | 0.0410105 | 0.082021 | 0.082021 | 0.164042 | 0.0442708 | 0.09375 | 0.177083 | 50 mmø-25 mmø | 0.082021 | 0.082021
997918 | 1CC1 | 10002 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.66121 | 0.0375 | 0.0708333 | 0.082021 | 0.131234 | 0.082021 | 0.262467 | 0.0442708 | 0.09375 | 0.177083 | 80 mmø-50 mmø | 0.131234 | 0.131234
691435 | TOF Footing | 6435 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0375 | 0.0708333 | 0.0410105 | 0.082021 | 0.082021 | 0.164042 | 0.0442708 | 0.09375 | 0.177083 | 50 mmø-25 mmø | 0.082021 | 0.082021
681371 | TOF Footing | 5225 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.046875 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0375 | 0.0875 | 0.0410105 | 0.106627 | 0.082021 | 0.213255 | 0.0546875 | 0.09375 | 0.21875 | 65 mmø-25 mmø | 0.106627 | 0.106627
1028930 | 2BC2 | 11709 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.130208 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.98519 | 0.104167 | 0.204167 | 0.131234 | 0.246063 | 0.262467 | 0.492126 | 0.127604 | 0.260417 | 0.510417 | 150 mmø-80 mmø | 0.246063 | 0.246063
704656 | TOF Footing | 7912 | Domestic Hot Water | Domestic Hot Water 1 | 10 | yes | no | no | 0.114583 | 10 | 0.0572917 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0458333 | 0.0291667 | 0.0524934 | 0.0328084 | 0.104987 | 0.0656168 | 0.0286458 | 0.114583 | 0.0729167 | 32 mmø-20 mmø | 0.0328084 | 0.0328084
1050666 | 2DC1 | 12680 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.98499 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1028584 | 1AC3 | 11665 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1051470 | 2B4 | 12912 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.9582 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0653066 | 0.0656168
1027225 | 1B07 | 11344 | Fire Protection Wet | Fire Protection | 10.0053 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0709246
687871 | Level 1 | 5975 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.786419 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
1030154 | 2D14 | 11833 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
683842 | TOF Footing | 5471 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0364583 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0375 | 0.0328084 | 0.0410105 | 0.0656168 | 0.082021 | 0.0234375 | 0.0729167 | 0.09375 | 25 mmø-20 mmø | 0.0410105 | 0.0410105
1052287 | 2BC1 | 13080 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.98518 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
690638 | TOF Footing | 6310 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
699943 | TOF Footing | 7372 | Domestic Hot Water | Domestic Hot Water 1 | 10 | yes | no | no | 0.09375 | 10 | 0.046875 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0375 | 0.0291667 | 0.0410105 | 0.0328084 | 0.082021 | 0.0656168 | 0.0234375 | 0.09375 | 0.0729167 | 25 mmø-20 mmø | 0.0328084 | 0.0328084
690917 | Level 1 | 6337 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.046875 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.657288 | 0.0375 | 0.0541667 | 0.0410105 | 0.0656168 | 0.082021 | 0.131234 | 0.0338542 | 0.09375 | 0.135417 | 40 mmø-25 mmø | 0.0656168 | 0.0656168
1013203 | 1DC4 | 10731 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0235 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.089076 | 0.0656168
1027175 | 1B04 | 11324 | Fire Protection Wet | Fire Protection | 9.9837 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.049315
684112 | TOF Footing | 5514 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1051438 | 2B9 | 12896 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.9582 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0653066 | 0.0656168
1049261 | 2D05 | 12296 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1027051 | 1B19 | 11284 | Fire Protection Wet | Fire Protection | 10.0019 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0675147
679923 | TOF Footing | 5083 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1013187 | 1D14 | 10723 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1051357 | 2BC1 | 12872 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.9582 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0653066 | 0.0656168
692193 | Level 2 | 6478 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.2 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
709180 | TOF Footing | 8485 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
701857 | TOF Footing | 7556 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.114583 | 10 | 0.0260417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0458333 | 0.0246063 | 0.0524934 | 0.0492126 | 0.104987 | 0.0286458 | 0.0520833 | 0.114583 | 32 mmø-15 mmø | 0.0524934 | 0.0524934
648101 | 1C09 | 3252 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.0333375 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
686368 | Level 1 | 5782 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0364583 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.975394 | 0.0291667 | 0.0375 | 0.0328084 | 0.0410105 | 0.0656168 | 0.082021 | 0.0234375 | 0.0729167 | 0.09375 | 25 mmø-20 mmø | 0.0410105 | 0.0410105
689105 | Level 1 | 6142 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.046875 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.657288 | 0.0375 | 0.0541667 | 0.0410105 | 0.0656168 | 0.082021 | 0.131234 | 0.0338542 | 0.09375 | 0.135417 | 40 mmø-25 mmø | 0.0656168 | 0.0656168
678559 | TOF Footing | 4960 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
1013113 | 1D19 | 10703 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0088 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0744117 | 0.0656168
685404 | TOF Footing | 5670 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
660847 | Level 1 | 3981 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.177083 | 10 | 0.0885417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.97301 | 0.0708333 | 0.0541667 | 0.082021 | 0.0656168 | 0.164042 | 0.131234 | 0.0442708 | 0.177083 | 0.135417 | 50 mmø-40 mmø | 0.0656168 | 0.0656168
690362 | TOF Footing | 6281 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
686724 | TOF Footing | 5831 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
719287 | 1A05 | 9496 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.45 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
689755 | TOF Footing | 6202 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1049351 | 2D05 | 12336 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
693703 | 1E33 | 6635 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
1026964 | 1B12 | 11252 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 9.98146 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.047072 | 0.0656168
646398 | TOF Footing | 3067 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.501164 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
684616 | TOF Footing | 5574 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0260417 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0375 | 0.0246063 | 0.0410105 | 0.0492126 | 0.082021 | 0.0234375 | 0.0520833 | 0.09375 | 25 mmø-15 mmø | 0.0410105 | 0.0410105
680040 | TOF Footing | 5088 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
718620 | 1AC3 | 9432 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1026440 | 1EC1 | 11084 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
692406 | Level 1 | 6508 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.34375 | 10 | 0.0572917 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -0.411 | 0.0458333 | 0.1375 | 0.0524934 | 0.164042 | 0.104987 | 0.328084 | 0.0859375 | 0.114583 | 0.34375 | 100 mmø-32 mmø | 0.164042 | 0.164042
630572 | TOF Footing | 1004 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.501123 | 0.0375 | 0.0708333 | 0.082021 | 0.0524934 | 0.082021 | 0.104987 | 0.0442708 | 0.09375 | 0.177083 | 50 mmø-32 mmø | 0.0524934 | 0.104987
661158 | 1CC1 | 4026 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.260417 | 10 | 0.0885417 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.0708333 | 0.104167 | 0.082021 | 0.131234 | 0.164042 | 0.262467 | 0.0651042 | 0.177083 | 0.260417 | 80 mmø-50 mmø | 0.131234 | 0.131234
704120 | TOF Footing | 7852 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1051764 | 2C23 | 12964 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
686956 | TOF Footing | 5864 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.0260417 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0875 | 0.0246063 | 0.106627 | 0.0492126 | 0.213255 | 0.0546875 | 0.0520833 | 0.21875 | 65 mmø-15 mmø | 0.106627 | 0.106627
1050541 | 2BC2 | 12648 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
695217 | 1C10 | 6785 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
659356 | 1D16 | 3805 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
680322 | Level 1 | 5129 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.046875 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.657288 | 0.0375 | 0.0541667 | 0.0410105 | 0.0656168 | 0.082021 | 0.131234 | 0.0338542 | 0.09375 | 0.135417 | 40 mmø-25 mmø | 0.0656168 | 0.0656168
690485 | TOF Footing | 6291 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
687699 | TOF Footing | 5953 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0572917 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.501123 | 0.0458333 | 0.1375 | 0.0524934 | 0.164042 | 0.104987 | 0.328084 | 0.0859375 | 0.114583 | 0.34375 | 100 mmø-32 mmø | 0.164042 | 0.164042
680544 | TOF Footing | 5155 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1050460 | 2B15 | 12624 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
632945 | TOF Footing | 1277 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.130208 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.104167 | 0.1375 | 0.131234 | 0.164042 | 0.262467 | 0.328084 | 0.0859375 | 0.260417 | 0.34375 | 100 mmø-80 mmø | 0.164042 | 0.164042
685108 | TOF Footing | 5653 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
711135 | TOF Footing | 8707 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
709347 | TOF Footing | 8496 | Domestic Hot Water | Domestic Hot Water 1 | 10 | yes | no | no | 0.135417 | 10 | 0.0677083 | 0.0260417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.285713 | 0.0541667 | 0.0208333 | 0.0656168 | 0.0246063 | 0.131234 | 0.0492126 | 0.0338542 | 0.135417 | 0.0520833 | 40 mmø-15 mmø | 0.0246063 | 0.0246063
690434 | TOF Footing | 6286 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0260417 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0375 | 0.0246063 | 0.0410105 | 0.0492126 | 0.082021 | 0.0234375 | 0.0520833 | 0.09375 | 25 mmø-15 mmø | 0.0410105 | 0.0410105
692405 | Level 1 | 6507 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.34375 | 10 | 0.0572917 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -0.411 | 0.0458333 | 0.1375 | 0.0524934 | 0.164042 | 0.104987 | 0.328084 | 0.0859375 | 0.114583 | 0.34375 | 100 mmø-32 mmø | 0.164042 | 0.164042
688436 | Level 1 | 6052 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.786419 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
687199 | TOF Footing | 5887 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.046875 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0375 | 0.0875 | 0.0410105 | 0.106627 | 0.082021 | 0.213255 | 0.0546875 | 0.09375 | 0.21875 | 65 mmø-25 mmø | 0.106627 | 0.106627
655916 | 1E12 | 3487 | Sanitary | Sanitary 1 | 9.97272 | no | no | yes | 0.34375 | 10 | 0.171875 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.1375 | 0.1375 | 0.164042 | 0.164042 | 0.328084 | 0.328084 | 0.0859375 | 0.34375 | 0.34375 | 100 mmø-100 mmø | 0.164042 | 0.136761
688109 | TOF Footing | 6006 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
700318 | TOF Footing | 7394 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0364583 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0375 | 0.0328084 | 0.0410105 | 0.0656168 | 0.082021 | 0.0234375 | 0.0729167 | 0.09375 | 25 mmø-20 mmø | 0.0410105 | 0.0410105
1051844 | 2C24 | 12984 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
666117 | 2C23 | 4588 | Sanitary | Sanitary 1 | 10.0106 | yes | no | no | 0.177083 | 10 | 0.0885417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.2 | 0.0708333 | 0.0458333 | 0.082021 | 0.0524934 | 0.164042 | 0.104987 | 0.0442708 | 0.177083 | 0.114583 | 50 mmø-32 mmø | 0.0524934 | 0.0630666
683830 | TOF Footing | 5468 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.34375 | 10 | 0.046875 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0375 | 0.1375 | 0.0410105 | 0.164042 | 0.082021 | 0.328084 | 0.0859375 | 0.09375 | 0.34375 | 100 mmø-25 mmø | 0.164042 | 0.164042
708895 | TOF Footing | 8444 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.114583 | 10 | 0.0260417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0458333 | 0.0246063 | 0.0524934 | 0.0492126 | 0.104987 | 0.0286458 | 0.0520833 | 0.114583 | 32 mmø-15 mmø | 0.0524934 | 0.0524934
706305 | TOF Footing | 8088 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0260417 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0375 | 0.0246063 | 0.0410105 | 0.0492126 | 0.082021 | 0.0234375 | 0.0520833 | 0.09375 | 25 mmø-15 mmø | 0.0410105 | 0.0410105
1027411 | 1BC2 | 11392 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0009 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0665114 | 0.0656168
1049890 | 2D16 | 12464 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1012526 | 1E15 | 10511 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1076222 | 1D13 | 13859 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.410319 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
660672 | 1CC1 | 3943 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.130208 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.104167 | 0.1375 | 0.131234 | 0.164042 | 0.262467 | 0.328084 | 0.0859375 | 0.260417 | 0.34375 | 100 mmø-80 mmø | 0.164042 | 0.164042
