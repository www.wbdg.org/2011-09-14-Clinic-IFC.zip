Properties of the parts of a building model (IFC2X3), part 12 of 295

# IfcFlowFitting: 45 Degree (707)
Name | In | Length 2 | Length 1 | Mark | System Type | System Name | ASHRAE Table | Level | Host | Offset (m) | Size | OffsetHeight | OffsetWidth | Num8 | Num7 | Num6 | Num5 | Num4 | Num3 | Num2 | Num1 | PSet_Revit_Other, Delta 2 | PSet_Revit_Other, Delta 1 | WidthOffset | WidthDelta | Width2 = Lining Width 2 = Insulation Width 2 | Width1 = Lining Width 1 = Insulation Width 1 | MaxDelta = Length 01 = Computed Length | Lining Height 2 = Insulation Height 2 = Height2 | Lining Height 1 = Insulation Height 1 = Height1 | HeightOffset | HeightDelta | Half Width 2 | Half Width 1 | Half Height 2 | Half Height 1
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568792 | 1A01 | 0.246063 | 0.246063 | 5590 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568694 | 1E16 | 0.246063 | 0.246063 | 5520 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:566977 | 1DC1 | 0.198016 | 0.594049 | 964 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.93 | 500x300-500x150 | 0.492126 | 0.82021 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.64042 | 1.64042 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.82021 | 0.82021 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567106 | 1E28 | 0.594049 | 0.198016 | 1207 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.50893 | 300x300-150x350 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.574147 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570402 | 2D09 | 0.164042 | 0.164042 | 8937 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Round Transition - Angle:45 Degree:45 Degree:568270 | 1DC3 | 0.082021 | 0.082021 | 4776 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 2 | Level : Level 2 | -0.87 | 400ø-350ø | 0.656168 | 0.656168 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0546807; OffsetHeightTemp: 0.0546807; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.574147; R0: 0.656168; Lining Radius 1: 0.574147; Lining Radius 0: 0.656168; Insulation Radius 1: 0.574147; Insulation Radius 0: 0.656168; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular Transition - Angle:45 Degree:45 Degree:567929 | 1A06 | 0.297024 | 0.198016 | 3604 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.25095 | 275x250-200x300 | 0.410105 | 0.451115 | 1 | 1 | 1 | 1 | 1.5 | 2.25 | 1.5 | 1.5 | 0 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.297024 | 0.984252 | 0.82021 | 10 | 0.164042 | 0.328084 | 0.451115 | 0.492126 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568659 | 1D28 | 0.246063 | 0.246063 | 5499 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569158 | 2AC2 | 0.198016 | 0.990081 | 6155 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.73 | 350x400-350x150 | 0.656168 | 0.574147 | 5 | 25 | 5 | 5 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.990081 | 0.492126 | 1.31234 | 10 | 0.82021 | 0.574147 | 0.574147 | 0.246063 | 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568760 | 1A02 | 0.164042 | 0.164042 | 5569 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Round Transition - Angle:45 Degree:45 Degree:568433 | 1E25 | 0.082021 | 0.082021 | 5227 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 1 | Level : Level 1 | 3.79951 | 200ø-150ø | 0.328084 | 0.328084 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0273403; OffsetHeightTemp: 0.0273403; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.246063; R0: 0.328084; Lining Radius 1: 0.246063; Lining Radius 0: 0.328084; Insulation Radius 1: 0.246063; Insulation Radius 0: 0.328084; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular Transition - Angle:45 Degree:45 Degree:567956 | 1A01 | 0.198016 | 0.198016 | 3731 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -0.860475 | 250x200-200x200 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.656168 | 0.82021 | 0.198016 | 0.656168 | 0.656168 | 10 | 0 | 0.328084 | 0.410105 | 0.328084 | 0.328084
M_Round Transition - Angle:45 Degree:45 Degree:567918 | 1AC5 | 0.082021 | 0.082021 | 3574 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 2 | Level : Level 2 | -0.87 | 200ø-150ø | 0.246063 | 0.246063 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 1.77636e-15; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0205052; OffsetHeightTemp: 0.0205052; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.328084; R0: 0.246063; Lining Radius 1: 0.328084; Lining Radius 0: 0.246063; Insulation Radius 1: 0.328084; Insulation Radius 0: 0.246063; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular Transition - Angle:45 Degree:45 Degree:569281 | 2C04 | 0.297024 | 0.396032 | 6461 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.17048 | 200x350-275x250 | 0.410105 | 0.451115 | 2 | 4 | 2 | 2 | 1.5 | 2.25 | 1.5 | 1.5 | 0 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.396032 | 1.14829 | 0.82021 | 10 | 0.328084 | 0.328084 | 0.451115 | 0.574147 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568715 | 1B19 | 0 | 0 | 5535 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-300ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 0; Num 7: 0; Num 6: 0; Num 10: 0; Num 1: 0; Length 8: 0; Length 7: 0; Length 6: 0; Length 5: 0; Length 4: 0; Half H0: 0.492126; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0; Delta 1: 0; W0: 0.984252; Radius: 0.492126; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.492126; Lining H0: 0.984252; Length01: 0.246063; Insulation W0: 0.984252; Insulation Radius: 0.492126; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.984252
M_Rectangular Transition - Angle:45 Degree:45 Degree:570524 | 1B02 | 2.17818 | 0.594049 | 9189 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 2 | Level : Level 2 | -1.116 | 800x300-250x150 | 0.246063 | 0.410105 | 3 | 9 | 3 | 3 | 11 | 121 | 11 | 11 | 0 | 0 | 10 | 1.80446 | 2.62467 | 0.82021 | 2.17818 | 0.984252 | 0.492126 | 10 | 0.492126 | 1.31234 | 0.410105 | 0.492126 | 0.246063
M_Rectangular Transition - Angle:45 Degree:45 Degree:568191 | 1DC1 | 0.495041 | 0.198016 | 4455 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.36048 | 425x350-300x300 | 0.573983 | 0.697178 | 1 | 1 | 0.998 | 1.002 | 2.5 | 6.25 | 2.5 | 2.5 | 0.000164042 | 0 | 10 | 0.410105 | 0.984252 | 1.39436 | 0.495041 | 0.984252 | 1.14829 | 9.99984 | 0.164042 | 0.492126 | 0.697178 | 0.492126 | 0.574147
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568799 | 1D24 | 0.164042 | 0.164042 | 5594 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570254 | 2C08 | 0.164042 | 0.164042 | 8856 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568662 | 1E11 | 0.164042 | 0.164042 | 5501 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568669 | 1D25 | 0.164042 | 0.164042 | 5505 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:567462 | 1B04 | 0.693057 | 0.193727 | 2184 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.69952 | 575x450-400x400 | 0.706939 | 0.943241 | 1 | 1 | 0.619 | 1.381 | 3.5 | 12.25 | 3.5 | 3.5 | 0.03125 | 0 | 10 | 0.574147 | 1.31234 | 1.88648 | 0.693057 | 1.31234 | 1.47638 | 9.96875 | 0.164042 | 0.656168 | 0.943241 | 0.656168 | 0.738189
M_Rectangular Transition - Angle:45 Degree:45 Degree:569434 | 2A06 | 0.495041 | 0.396032 | 6869 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07045 | 275x250-150x350 | 0.409941 | 0.451115 | 2 | 4 | 1.998 | 2.002 | 2.5 | 6.25 | 2.5 | 2.5 | 0.000164042 | 0 | 10 | 0.410105 | 0.492126 | 0.902231 | 0.495041 | 1.14829 | 0.82021 | 9.99984 | 0.328084 | 0.246063 | 0.451115 | 0.574147 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570284 | 2A13 | 0 | 0 | 8872 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-300ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 0; Num 7: 0; Num 6: 0; Num 10: 0; Num 1: 0; Length 8: 0; Length 7: 0; Length 6: 0; Length 5: 0; Length 4: 0; Half H0: 0.492126; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0; Delta 1: 0; W0: 0.984252; Radius: 0.492126; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.492126; Lining H0: 0.984252; Length01: 0.246063; Insulation W0: 0.984252; Insulation Radius: 0.492126; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.984252
M_Round Transition - Angle:45 Degree:45 Degree:567588 | 1D25 | 0.164042 | 0.164042 | 2551 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 1 | Level : Level 1 | 3.28098 | 400ø-300ø | 0.656168 | 0.656168 | PSet_Revit_Other - Num 1: 1.9685; Num 5: 4.75239; Num 4: 1; Num 3: 3.93701; Num 2: 1.9685; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0546807; OffsetHeightTemp: 0.0546807; WidthOffsetfromBase: 10; Offest Delta: 2.84217e-14; DiameterDelta: 0.164042; R1: 0.492126; R0: 0.656168; Lining Radius 1: 0.492126; Lining Radius 0: 0.656168; Insulation Radius 1: 0.492126; Insulation Radius 0: 0.656168; HeightOffsetfromBase: 10; ComputedLength: 0.396032
M_Rectangular Transition - Angle:45 Degree:45 Degree:569380 | 2C19 | 0.198016 | 0.198016 | 6775 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.43 | 200x250-150x250 | 0.410105 | 0.328084 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.492126 | 0.656168 | 0.198016 | 0.82021 | 0.82021 | 10 | 0 | 0.246063 | 0.328084 | 0.410105 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570269 | 2AC3 | 0.246063 | 0.246063 | 8864 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570279 | 2A12 | 0.082021 | 0.082021 | 8869 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570419 | 2C04 | 0 | 0 | 8948 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-300ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 0; Num 7: 0; Num 6: 0; Num 10: 0; Num 1: 0; Length 8: 0; Length 7: 0; Length 6: 0; Length 5: 0; Length 4: 0; Half H0: 0.492126; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0; Delta 1: 0; W0: 0.984252; Radius: 0.492126; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.492126; Lining H0: 0.984252; Length01: 0.246063; Insulation W0: 0.984252; Insulation Radius: 0.492126; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.984252
M_Rectangular Transition - Angle:45 Degree:45 Degree:567362 | 1BC4 | 0.792065 | 0.198016 | 1779 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 2.98358 | 300x300-100x250 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 4 | 16 | 4 | 4 | 0 | 0 | 10 | 0.656168 | 0.328084 | 0.984252 | 0.792065 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.164042 | 0.492126 | 0.410105 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570289 | 2A07 | 0 | 0 | 8875 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-300ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 0; Num 7: 0; Num 6: 0; Num 10: 0; Num 1: 0; Length 8: 0; Length 7: 0; Length 6: 0; Length 5: 0; Length 4: 0; Half H0: 0.492126; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0; Delta 1: 0; W0: 0.984252; Radius: 0.492126; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.492126; Lining H0: 0.984252; Length01: 0.246063; Insulation W0: 0.984252; Insulation Radius: 0.492126; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.984252
M_Round Transition - Angle:45 Degree:45 Degree:568259 | 1D13 | 0.082021 | 0.082021 | 4730 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 1 | Level : Level 1 | 3.5095 | 200ø-150ø | 0.328084 | 0.328084 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0273403; OffsetHeightTemp: 0.0273403; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.246063; R0: 0.328084; Lining Radius 1: 0.246063; Lining Radius 0: 0.328084; Insulation Radius 1: 0.246063; Insulation Radius 0: 0.328084; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568712 | 1E05 | 0.246063 | 0.246063 | 5531 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567060 | 1DC7 | 0.198016 | 0.594049 | 1102 | Return Air | Mechanical Return Air 1 |  | Level 1 | Level : Level 1 | 3.64 | 1100x450-1100x300 | 0.738189 | 1.80446 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 3.60892 | 3.60892 | 0.594049 | 0.984252 | 1.47638 | 10 | 0.492126 | 1.80446 | 1.80446 | 0.492126 | 0.738189
M_Rectangular Transition - Angle:45 Degree:45 Degree:570545 | 1D39 | 2.17818 | 0.594049 | 9248 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 2 | Level : Level 2 | -1.25093 | 800x300-250x150 | 0.246063 | 0.410105 | 3 | 9 | 3 | 3 | 11 | 121 | 11 | 11 | 0 | 0 | 10 | 1.80446 | 2.62467 | 0.82021 | 2.17818 | 0.984252 | 0.492126 | 10 | 0.492126 | 1.31234 | 0.410105 | 0.492126 | 0.246063
M_Rectangular Transition - Angle:45 Degree:45 Degree:567522 | 1B17 | 0.0990081 | 0.198016 | 2315 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.49995 | 275x250-250x250 | 0.410269 | 0.451115 | 1 | 1 | 1 | 1 | 0.5 | 0.25 | 0.5 | 0.5 | 0.000164042 | 0 | 10 | 0.082021 | 0.82021 | 0.902231 | 0.0990081 | 0.82021 | 0.82021 | 10.0002 | 0 | 0.410105 | 0.451115 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:568485 | 1A16 | 0.198016 | 0.198016 | 5300 | Return Air | Mechanical Return Air 1 |  | Level 2 | Level : Level 2 | -1.325 | 350x200-350x150 | 0.328084 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.574147 | 0.574147 | 0.246063 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:569070 | 2A11 | 0.198016 | 0.198016 | 5877 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.68 | 250x200-250x150 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.82021 | 0.82021 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.410105 | 0.410105 | 0.246063 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:569990 | 2D18 | 1.38611 | 0.396032 | 8370 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 4 | 650x200-300x300 | 0.492126 | 0.492126 | 2 | 4 | 2 | 2 | 7 | 49 | 7 | 7 | 0 | 0 | 10 | 1.14829 | 2.13255 | 0.984252 | 1.38611 | 0.656168 | 0.984252 | 10 | 0.328084 | 1.06627 | 0.492126 | 0.328084 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570542 | Level 1 | 2.17818 | 0.594049 | 9245 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 2 | Level : Level 2 | -1.25093 | 800x300-250x150 | 0.246063 | 0.410105 | 3 | 9 | 3 | 3 | 11 | 121 | 11 | 11 | 0 | 0 | 10 | 1.80446 | 2.62467 | 0.82021 | 2.17818 | 0.984252 | 0.492126 | 10 | 0.492126 | 1.31234 | 0.410105 | 0.492126 | 0.246063
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568432 | 1E25 | 0.246063 | 0.246063 | 5226 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568246 | 1DC4 | 0.198016 | 0.198016 | 4656 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.06048 | 350x300-300x250 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.984252 | 1.14829 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.492126 | 0.574147 | 0.410105 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568771 | 1AC5 | 0.082021 | 0.082021 | 5575 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular Transition - Angle:45 Degree:45 Degree:567564 | 1BC1 | 0.396032 | 0.198016 | 2387 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.79952 | 350x300-250x250 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.82021 | 1.14829 | 0.396032 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.410105 | 0.574147 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569945 | 2D21 | 0.594049 | 0.594049 | 8308 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.61893 | 300x300-150x450 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.47638 | 0.984252 | 10 | 0.492126 | 0.246063 | 0.492126 | 0.738189 | 0.492126
M_Round Transition - Angle:45 Degree:45 Degree:567338 | 1EC1 | 0.082021 | 0.082021 | 1722 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 1 | Level : Level 1 | 3.79 | 400ø-350ø | 0.656168 | 0.656168 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0546807; OffsetHeightTemp: 0.0546807; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.574147; R0: 0.656168; Lining Radius 1: 0.574147; Lining Radius 0: 0.656168; Insulation Radius 1: 0.574147; Insulation Radius 0: 0.656168; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570381 | 2DC2 | 0.164042 | 0.164042 | 8925 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570246 | 2C03 | 0.164042 | 0.164042 | 8852 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:568253 | 1D13 | 0.0990081 | 0.198016 | 4714 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.06045 | 275x250-250x250 | 0.409941 | 0.451115 | 1 | 1 | 1 | 1 | 0.5 | 0.25 | 0.5 | 0.5 | 0.000164042 | 0 | 10 | 0.082021 | 0.82021 | 0.902231 | 0.0990081 | 0.82021 | 0.82021 | 9.99984 | 0 | 0.410105 | 0.451115 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:566985 | 1E16 | 0.792065 | 0.396032 | 981 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.815 | 500x200-300x300 | 0.492126 | 0.492126 | 2 | 4 | 2 | 2 | 4 | 16 | 4 | 4 | 0 | 0 | 10 | 0.656168 | 1.64042 | 0.984252 | 0.792065 | 0.656168 | 0.984252 | 10 | 0.328084 | 0.82021 | 0.492126 | 0.328084 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567989 | 1A16 | 0.198016 | 0.198016 | 3861 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -0.8605 | 250x250-200x250 | 0.410105 | 0.410105 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.656168 | 0.82021 | 0.198016 | 0.82021 | 0.82021 | 10 | 0 | 0.328084 | 0.410105 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:568543 | 1D40 | 0.198016 | 0.594049 | 5393 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.715 | 350x300-350x150 | 0.492126 | 0.574147 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.574147 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569163 | 2AC2 | 0.198016 | 0.594049 | 6166 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.73 | 350x400-350x250 | 0.656168 | 0.574147 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.594049 | 0.82021 | 1.31234 | 10 | 0.492126 | 0.574147 | 0.574147 | 0.410105 | 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568619 | 1DC3 | 0.246063 | 0.246063 | 5473 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568457 | 1C08 | 0.198016 | 0.198016 | 5257 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.64 | 350x200-350x150 | 0.328084 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.574147 | 0.574147 | 0.246063 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:566922 | 1A07 | 0.198016 | 0.594049 | 841 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.35893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570260 | 2C01 | 0.164042 | 0.164042 | 8859 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Round Transition - Angle:45 Degree:45 Degree:570709 | 1DC7 | 0.0818134 | 0.0822286 | 546 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 1 | Level : Level 1 | 3.3 | 350ø-300ø | 0.49212 | 0.492334 | PSet_Revit_Other - Num 1: 0.986743; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.981761; Length 3: 0.000207621; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0410278; OffsetHeightTemp: 0.04101; WidthOffsetfromBase: 10.0002; Offest Delta: 0.000207621; DiameterDelta: 0.082021; R1: 0.574147; R0: 0.492126; Lining Radius 1: 0.574147; Lining Radius 0: 0.492126; Insulation Radius 1: 0.574147; Insulation Radius 0: 0.492126; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular Transition - Angle:45 Degree:45 Degree:569984 | 2D16 | 0.198016 | 0.594049 | 8360 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568545 | 1D40 | 0.198016 | 0.594049 | 5395 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.43393 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569360 | 2C10 | 0.198016 | 0.594049 | 6738 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07048 | 350x300-400x150 | 0.246063 | 0.656168 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 1.31234 | 0.594049 | 0.984252 | 0.492126 | 10 | 0.492126 | 0.574147 | 0.656168 | 0.492126 | 0.246063
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568762 | 1A02 | 0.164042 | 0.164042 | 5570 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567601 | 1D25 | 0.164042 | 0.164042 | 2592 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:566937 | 1AC2 | 0.396032 | 0.594049 | 885 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.01893 | 300x300-400x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 1.31234 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.656168 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570187 | 2D04 | 0.396032 | 0.594049 | 8703 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-400x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 1.31234 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.656168 | 0.492126 | 0.246063 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:569191 | 2CC5 | 0.164042 | 0.164042 | 6218 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567607 | 1D25 | 0.164042 | 0.164042 | 2598 | Supply Air | Mechanical Supply Air 1 | SD4-2 | Level 1 | Level : Level 1 | 3.2905 | 200ø-100x250 | 0.410105 | 0.164042 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 2; Length 8: 0.396032; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.410105; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.164042; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.164042; W0: 0.328084; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.328084; Lining Radius: 0.328084; Lining H0: 0.82021; Length01: 0.396032; Insulation W0: 0.328084; Insulation Radius: 0.328084; Insulation H0: 0.82021; H0: 0.82021; OffsetWidthTemp: -0.0138889; OffsetHeightTemp: 0.0347222; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:567015 | Level 1 | 0.198016 | 1.1881 | 1038 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.64 | 250x450-250x150 | 0.738189 | 0.410105 | 6 | 36 | 6 | 6 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.82021 | 0.82021 | 1.1881 | 0.492126 | 1.47638 | 10 | 0.984252 | 0.410105 | 0.410105 | 0.246063 | 0.738189
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570291 | 2A06 | 0 | 0 | 8876 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-300ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 0; Num 7: 0; Num 6: 0; Num 10: 0; Num 1: 0; Length 8: 0; Length 7: 0; Length 6: 0; Length 5: 0; Length 4: 0; Half H0: 0.492126; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0; Delta 1: 0; W0: 0.984252; Radius: 0.492126; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.492126; Lining H0: 0.984252; Length01: 0.246063; Insulation W0: 0.984252; Insulation Radius: 0.492126; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.984252
M_Round Transition - Angle:45 Degree:45 Degree:567701 | 1D38 | 0.246063 | 0.246063 | 2902 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 1 | Level : Level 1 | 3.69 | 500ø-350ø | 0.82021 | 0.82021 | PSet_Revit_Other - Num 1: 2.95276; Num 5: 7.12858; Num 4: 1; Num 3: 5.90551; Num 2: 2.95276; Length 3: 2.02061e-14; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0683508; OffsetHeightTemp: 0.0683508; WidthOffsetfromBase: 10; Offest Delta: -7.10543e-15; DiameterDelta: 0.246063; R1: 0.574147; R0: 0.82021; Lining Radius 1: 0.574147; Lining Radius 0: 0.82021; Insulation Radius 1: 0.574147; Insulation Radius 0: 0.82021; HeightOffsetfromBase: 10; ComputedLength: 0.594049
M_Rectangular Transition - Angle:45 Degree:45 Degree:566906 | 1D36 | 0.594049 | 0.198016 | 801 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.35893 | 300x300-150x250 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568323 | 1C07 | 0.297024 | 0.198016 | 4955 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -0.860473 | 275x250-200x200 | 0.409941 | 0.451115 | 1 | 1 | 0.998 | 1.002 | 1.5 | 2.25 | 1.5 | 1.5 | 0.000164042 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.297024 | 0.656168 | 0.82021 | 9.99984 | 0.164042 | 0.328084 | 0.451115 | 0.328084 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:569762 | 2D20 | 0.495041 | 0.198016 | 7830 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07048 | 425x350-300x300 | 0.574147 | 0.697178 | 1 | 1 | 1 | 1 | 2.5 | 6.25 | 2.5 | 2.5 | 0 | 0 | 10 | 0.410105 | 0.984252 | 1.39436 | 0.495041 | 0.984252 | 1.14829 | 10 | 0.164042 | 0.492126 | 0.697178 | 0.492126 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:570055 | 2B16 | 0.198016 | 0.594049 | 8504 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570182 | 2D03 | 0.198016 | 0.594049 | 8699 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-250x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 0.492126 | 0.246063 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567538 | 1B17 | 0.164042 | 0.164042 | 2339 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570385 | 2D18 | 0.246063 | 0.246063 | 8927 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570005 | 2D09 | 0.198016 | 0.594049 | 8389 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569206 | 2C13 | 0.297024 | 0.198016 | 6246 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.27048 | 275x250-200x250 | 0.410105 | 0.451115 | 1 | 1 | 1 | 1 | 1.5 | 2.25 | 1.5 | 1.5 | 0 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.297024 | 0.82021 | 0.82021 | 10 | 0 | 0.328084 | 0.451115 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:567153 | 1DC3 | 0.396032 | 0.198016 | 1349 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.3 | 350x200-250x150 | 0.328084 | 0.574147 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.82021 | 1.14829 | 0.396032 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.410105 | 0.574147 | 0.246063 | 0.328084
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570241 | 2C22 | 0.164042 | 0.164042 | 8849 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:570555 | 1AC3 | 0.594049 | 0.198016 | 68 | Return Air | Mechanical Return Air 1 |  | Level 2 | Level : Level 2 | -0.93 | 1000x350-850x350 | 0.574147 | 1.64042 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 2.78871 | 3.28084 | 0.594049 | 1.14829 | 1.14829 | 10 | 0 | 1.39436 | 1.64042 | 0.574147 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:568509 | 1DC1 | 0.198016 | 0.594049 | 5350 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.78 | 200x300-200x150 | 0.492126 | 0.328084 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.656168 | 0.656168 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.328084 | 0.328084 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567070 | 1E06 | 0.990081 | 0.198016 | 1127 | Return Air | Mechanical Return Air 1 |  | Level 1 | Level : Level 1 | 3.25 | 1100x300-850x300 | 0.492126 | 1.80446 | 1 | 1 | 1 | 1 | 5 | 25 | 5 | 5 | 0 | 0 | 10 | 0.82021 | 2.78871 | 3.60892 | 0.990081 | 0.984252 | 0.984252 | 10 | 0 | 1.39436 | 1.80446 | 0.492126 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568785 | 1E01 | 0.246063 | 0.246063 | 5586 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568393 | 1E06 | 0.164042 | 0.164042 | 5143 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:568234 | 1D16 | 0.396032 | 0.198016 | 4614 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.26052 | 250x250-150x250 | 0.410105 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.82021 | 0.82021 | 10 | 0 | 0.246063 | 0.410105 | 0.410105 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570312 | 2B25 | 0.246063 | 0.246063 | 8887 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567942 | 1A03 | 0.246063 | 0.246063 | 3655 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568617 | 1D11 | 0.164042 | 0.164042 | 5472 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:569935 | 2D17 | 0.198016 | 0.198016 | 8268 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.78 | 500x300-450x300 | 0.492126 | 0.82021 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.47638 | 1.64042 | 0.198016 | 0.984252 | 0.984252 | 10 | 0 | 0.738189 | 0.82021 | 0.492126 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567271 | 1D25 | 0.594049 | 0.594049 | 1498 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.51893 | 300x300-150x450 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.47638 | 0.984252 | 10 | 0.492126 | 0.246063 | 0.492126 | 0.738189 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569696 | 2D04-A | 0.495041 | 0.396032 | 7647 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.0705 | 475x450-350x350 | 0.738189 | 0.779199 | 2 | 4 | 2 | 2 | 2.5 | 6.25 | 2.5 | 2.5 | 0 | 0 | 10 | 0.410105 | 1.14829 | 1.5584 | 0.495041 | 1.14829 | 1.47638 | 10 | 0.328084 | 0.574147 | 0.779199 | 0.574147 | 0.738189
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568314 | 1D01 | 0.082021 | 0.082021 | 4919 | Supply Air | Mechanical Supply Air 1 | SD4-2 | Level 2 | Level : Level 2 | -1.27 | 150x250-200ø | 0.410105 | 0.246063 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.410105; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.246063; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.492126; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.492126; Lining Radius: 0.328084; Lining H0: 0.82021; Length01: 0.198016; Insulation W0: 0.492126; Insulation Radius: 0.328084; Insulation H0: 0.82021; H0: 0.82021; OffsetWidthTemp: -0.0208333; OffsetHeightTemp: 0.0347222; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568764 | 1A04 | 0.082021 | 0.082021 | 5571 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular Transition - Angle:45 Degree:45 Degree:567773 | 1D34 | 0.297024 | 0.198016 | 3103 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.30955 | 275x250-200x250 | 0.410269 | 0.451115 | 1 | 1 | 1 | 1 | 1.5 | 2.25 | 1.5 | 1.5 | 0.000164042 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.297024 | 0.82021 | 0.82021 | 10.0002 | 0 | 0.328084 | 0.451115 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:567474 | 1B19 | 0.495041 | 0.198016 | 2210 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.69955 | 425x350-300x350 | 0.574311 | 0.697178 | 1 | 1 | 1 | 1 | 2.5 | 6.25 | 2.5 | 2.5 | 0.000164042 | 0 | 10 | 0.410105 | 0.984252 | 1.39436 | 0.495041 | 1.14829 | 1.14829 | 10.0002 | 0 | 0.492126 | 0.697178 | 0.574147 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:570528 | 1B01 | 2.17818 | 0.594049 | 9202 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 2 | Level : Level 2 | -1.116 | 800x300-250x150 | 0.246063 | 0.410105 | 3 | 9 | 3 | 3 | 11 | 121 | 11 | 11 | 0 | 0 | 10 | 1.80446 | 2.62467 | 0.82021 | 2.17818 | 0.984252 | 0.492126 | 10 | 0.492126 | 1.31234 | 0.410105 | 0.492126 | 0.246063
