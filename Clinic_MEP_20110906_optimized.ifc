Properties of the parts of a building model (IFC2X3), part 59 of 295

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:567887
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:569512
In: Level 2
Type - ElementType: Oval Duct:Mitered Elbows / Taps:569512
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Equivalent Diameter: 2.5326; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 2.11828; Section: 497; Insulation Thickness: 0; Lining Thickness: 0; Area: 15.5504 m2
PSet_Revit_Constraints - Horizontal Justification: 1; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1488
PSet_Revit_Dimensions - Size: 1400/400; Width: 4.59318; Height: 1.31234; Length: 4.775 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:569513
In: Level 2
Type - ElementType: Oval Duct:Mitered Elbows / Taps:569513
PSet_Revit_Constraints - Horizontal Justification: 1; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Dimensions - Size: 1400/400; Width: 4.59318; Height: 1.31234; Length: 3.075 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Equivalent Diameter: 2.5326; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 2.11828; Section: 497; Insulation Thickness: 0; Lining Thickness: 0; Area: 10.0142 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Identity Data - Mark: 1489
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:569515
In: Level 2
Type - ElementType: Oval Duct:Mitered Elbows / Taps:569515
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Equivalent Diameter: 2.166; Size Lock: no; Loss Coefficient: 0.102117; Hydraulic Diameter: 1.95338; Section: 164; Insulation Thickness: 0; Lining Thickness: 0; Area: 10.3424 m2
PSet_Revit_Mechanical - Airflow - Flow: 255.148; Additional Flow: 0; Velocity: 64.8248; Friction: 0.528991; Pressure Drop: 7.30661; Velocity Pressure: 71.5514; Reynolds number: 783856
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 1; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1490
PSet_Revit_Dimensions - Size: 1000/400; Width: 3.28084; Height: 1.31234; Length: 4.21 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:569517
In: Level 2
Type - ElementType: Oval Duct:Mitered Elbows / Taps:569517
PSet_Revit_Dimensions - Size: 900/400; Width: 2.95276; Height: 1.31234; Length: 4.5 m
PSet_Revit_Identity Data - Mark: 1491
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Equivalent Diameter: 2.05794; Size Lock: no; Loss Coefficient: 0.112838; Hydraulic Diameter: 1.89388; Section: 173; Insulation Thickness: 0; Lining Thickness: 0; Area: 10.1549 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 240.14; Additional Flow: 0; Velocity: 68.5054; Friction: 0.61072; Pressure Drop: 9.01654; Velocity Pressure: 79.9071; Reynolds number: 803131
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:569569
In: Level 2
Type - ElementType: Oval Duct:Mitered Elbows / Taps:569569
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1524
PSet_Revit_Dimensions - Size: 850/400; Width: 2.78871; Height: 1.31234; Length: 1.7875 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Equivalent Diameter: 2.00055; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 1.86; Section: 496; Insulation Thickness: 0; Lining Thickness: 0; Area: 3.85499 m2
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:569571
In: Level 2
Type - ElementType: Oval Duct:Mitered Elbows / Taps:569571
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Equivalent Diameter: 1.50486; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 1.49252; Section: 504; Insulation Thickness: 0; Lining Thickness: 0; Area: 4.8069 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 500/400; Width: 1.64042; Height: 1.31234; Length: 3.3 m
PSet_Revit_Identity Data - Mark: 1525
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:570209
In: Level 2
Type - ElementType: Oval Duct:Mitered Elbows / Taps:570209
PSet_Revit_Identity Data - Mark: 1882
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.3 m; Start Offset: 3.3 m; End Offset: 3.3 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 1500/500; Width: 4.92126; Height: 1.64042; Length: 0.0343164 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.05 m; Top Elevation: 3.55 m; Equivalent Diameter: 2.95048; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 2.55922; Section: 788; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.122537 m2
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:570210
In: Level 2
Type - ElementType: Oval Duct:Mitered Elbows / Taps:570210
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -0.595 m; Start Offset: -0.595 m; End Offset: 3.025 m
PSet_Revit_Identity Data - Mark: 1883
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: -0.595 m; Top Elevation: 3.025 m; Equivalent Diameter: 2.95048; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 2.55922; Section: 788; Insulation Thickness: 0; Lining Thickness: 0; Area: 12.9263 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 1500/500; Width: 4.92126; Height: 1.64042; Length: 3.62 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:570223
In: Level 2
Type - ElementType: Oval Duct:Mitered Elbows / Taps:570223
PSet_Revit_Dimensions - Size: 1500/500; Width: 4.92126; Height: 1.64042; Length: 1.23 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: -0.605 m; Top Elevation: 0.625 m; Equivalent Diameter: 2.95048; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 2.55922; Section: 768; Insulation Thickness: 0; Lining Thickness: 0; Area: 4.39208 m2
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Identity Data - Mark: 1889
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -0.605 m; Start Offset: -0.605 m; End Offset: 0.625 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:994018
In: Level 1
Type - ElementType: Oval Duct:Mitered Elbows / Taps:994018
PSet_Revit_Identity Data - Mark: 220
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.69 m; Start Offset: 3.69 m; End Offset: 3.69 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 450/450; Width: 1.47638; Height: 1.47638; Length: 3.5011 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.465 m; Top Elevation: 3.915 m; Equivalent Diameter: 1.47638; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 1.47638; Section: 780; Insulation Thickness: 0; Lining Thickness: 0; Area: 4.94957 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Pipe Types:Cold Water:1054501
In: Level 2
Type - ElementType: Pipe Types:Cold Water:1054501
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 3.03988 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 23716.5; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 622; Area: 1.78353 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 4982
PSet_Revit_Dimensions - Outer Diameter: 0.208333; Inner Diameter: 0.197638; Size: 65 mmø; Diameter: 0.213255; Length: 8.73409 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.5 m; Start Offset: -1.5 m; End Offset: -1.5 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:1054505
In: Level 2
Type - ElementType: Pipe Types:Cold Water:1054505
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 3.03988 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 23716.5; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 622; Area: 0.0858931 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.5 m; Start Offset: -1.5 m; End Offset: -1.5 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.208333; Inner Diameter: 0.197638; Size: 65 mmø; Diameter: 0.213255; Length: 0.420625 m
PSet_Revit_Identity Data - Mark: 4983
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:1054519
In: Level 2
Type - ElementType: Pipe Types:Cold Water:1054519
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 2.98988 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 23716.5; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 265; Area: 0.0488636 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.55 m; Start Offset: -1.55 m; End Offset: -1.55 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.208333; Inner Diameter: 0.197638; Size: 65 mmø; Diameter: 0.213255; Length: 0.239289 m
PSet_Revit_Identity Data - Mark: 4984
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:1054694
In: Level 2
Type - ElementType: Pipe Types:Cold Water:1054694
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.5 m; Start Offset: -1.5 m; End Offset: -1.5 m; Slope: 0
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 3.03988 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 23716.5; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 622; Area: 0.0129269 m2
PSet_Revit_Dimensions - Outer Diameter: 0.208333; Inner Diameter: 0.197638; Size: 65 mmø; Diameter: 0.213255; Length: 0.063304 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 4989
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:1056703
In: Level 2
Type - ElementType: Pipe Types:Cold Water:1056703
PSet_Revit_Identity Data - Mark: 4991
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 3.2119 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 6381.89; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 624; Area: 0.006989 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.35 m; Start Offset: -1.35 m; End Offset: -1.35 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.0625; Inner Diameter: 0.0531824; Size: 20 mmø; Diameter: 0.0656168; Length: 0.111233 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:1056711
In: Level 2
Type - ElementType: Pipe Types:Cold Water:1056711
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.43729 m; Start Offset: -1.43729 m; End Offset: -1.36746 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 3.13271 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 6381.89; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 624; Area: 0.00438763 m2
PSet_Revit_Identity Data - Mark: 4992
PSet_Revit_Dimensions - Outer Diameter: 0.0625; Inner Diameter: 0.0531824; Size: 20 mmø; Diameter: 0.0656168; Length: 0.0698312 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:1056713
In: Level 2
Type - ElementType: Pipe Types:Cold Water:1056713
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 3.03988 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 23716.5; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 622; Area: 0.0182769 m2
PSet_Revit_Dimensions - Outer Diameter: 0.208333; Inner Diameter: 0.197638; Size: 65 mmø; Diameter: 0.213255; Length: 0.0895031 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 4993
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.5 m; Start Offset: -1.5 m; End Offset: -1.5 m; Slope: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:1060518
In: Level 1
Type - ElementType: Pipe Types:Cold Water:1060518
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: -0.44877 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 38401.6; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 625; Area: 1.20297 m2
PSet_Revit_Identity Data - Mark: 4994
PSet_Revit_Dimensions - Outer Diameter: 0.333333; Inner Diameter: 0.320013; Size: 100 mmø; Diameter: 0.328084; Length: 3.82919 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:1061736
In: Level 2
Type - ElementType: Pipe Types:Cold Water:1061736
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 6.266 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 11216.5; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 264; Area: 0.00255349 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.104167; Inner Diameter: 0.0934711; Size: 32 mmø; Diameter: 0.104987; Length: 0.0254 m
PSet_Revit_Identity Data - Mark: 5000
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 1.696 m; Start Offset: 1.696 m; End Offset: 1.7214 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:1061739
In: Level 2
Type - ElementType: Pipe Types:Cold Water:1061739
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 1.74521 m; Start Offset: 1.74521 m; End Offset: 1.74521 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.104167; Inner Diameter: 0.0934711; Size: 32 mmø; Diameter: 0.104987; Length: 0.231524 m
PSet_Revit_Identity Data - Mark: 5001
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 6.30097 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 11216.5; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 264; Area: 0.0232753 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:1061743
In: Level 2
Type - ElementType: Pipe Types:Cold Water:1061743
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.52619 m; Start Offset: -1.52619 m; End Offset: 1.7214 m
PSet_Revit_Dimensions - Outer Diameter: 0.104167; Inner Diameter: 0.0934711; Size: 32 mmø; Diameter: 0.104987; Length: 3.24759 m
PSet_Revit_Identity Data - Mark: 5002
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 3.04381 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 11216.5; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 264; Area: 0.326483 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:1076245
In: Level 1
Type - ElementType: Pipe Types:Cold Water:1076245
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 3; Insulation Thickness: 0; Invert Elevation: 0.82055 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 1815.62; Section: 266; Area: 0.00374399 m2
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.07945 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.9 m; Start Offset: 0.9 m; End Offset: 0.82055 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 5121
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:1076247
In: Level 1
Type - ElementType: Pipe Types:Cold Water:1076247
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 3; Insulation Thickness: 0; Invert Elevation: 0.800933 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 141.249; Section: 266; Area: 0.000291269 m2
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.00618092 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.806263 m; Start Offset: 0.806263 m; End Offset: 0.806263 m; Slope: 0
PSet_Revit_Identity Data - Mark: 5122
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
