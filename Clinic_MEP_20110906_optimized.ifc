Properties of the parts of a building model (IFC2X3), part 130 of 295

# IfcFlowSegment: Pipe Types:Fire Protection:1052361
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052370
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052370
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 3.74906 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.985 m; Start Offset: 2.985 m; End Offset: 2.985 m; Slope: 0
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.53758 m; Section: 443; Area: 0.47112 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 4873
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052377
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052377
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.68 m; Start Offset: 2.68 m; End Offset: 2.94134 m
PSet_Revit_Identity Data - Mark: 4874
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.25 m; Section: 438; Area: 0.0123155 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.261344 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052386
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052386
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 4876
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 2.62091 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.985 m; Start Offset: 2.985 m; End Offset: 2.985 m; Slope: 0
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.53758 m; Section: 908; Area: 0.329354 m2
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052411
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052411
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 4877
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.68 m; Start Offset: 2.68 m; End Offset: 2.94134 m
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.25 m; Section: 436; Area: 0.0123155 m2
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.261344 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052419
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052419
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 2.18743 m
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.53758 m; Section: 1319; Area: 0.274881 m2
PSet_Revit_Identity Data - Mark: 4879
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.985 m; Start Offset: 2.985 m; End Offset: 2.985 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052440
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052440
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.68 m; Start Offset: 2.68 m; End Offset: 2.94134 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.25 m; Section: 434; Area: 0.0123155 m2
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.261344 m
PSet_Revit_Identity Data - Mark: 4880
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052448
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052448
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.53758 m; Section: 909; Area: 0.382435 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.985 m; Start Offset: 2.985 m; End Offset: 2.985 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 3.04333 m
PSet_Revit_Identity Data - Mark: 4882
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052464
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052464
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.25 m; Section: 432; Area: 0.0123155 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.68 m; Start Offset: 2.68 m; End Offset: 2.94134 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 4883
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.261344 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052472
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052472
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 4885
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.985 m; Start Offset: 2.985 m; End Offset: 2.985 m; Slope: 0
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.53758 m; Section: 910; Area: 0.421643 m2
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 3.35533 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052490
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052490
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.68 m; Start Offset: 2.68 m; End Offset: 2.94134 m
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.25 m; Section: 430; Area: 0.0123155 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.261344 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 4886
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052492
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052492
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 4.23406 m
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.53758 m; Section: 429; Area: 0.532067 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.985 m; Start Offset: 2.985 m; End Offset: 2.985 m; Slope: 0
PSet_Revit_Identity Data - Mark: 4887
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052498
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052498
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.985 m; Start Offset: 2.985 m; End Offset: 2.985 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 3.23633 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 4888
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.53758 m; Section: 911; Area: 0.406689 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052518
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052518
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.25 m; Section: 428; Area: 0.0136995 m2
PSet_Revit_Identity Data - Mark: 4889
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.68 m; Start Offset: 2.68 m; End Offset: 2.97071 m
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.290713 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052536
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052536
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.68 m; Start Offset: 2.68 m; End Offset: 2.97071 m
PSet_Revit_Identity Data - Mark: 4890
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.290713 m
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.25 m; Section: 470; Area: 0.0136995 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052564
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052564
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.25 m; Section: 468; Area: 0.0123155 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.68 m; Start Offset: 2.68 m; End Offset: 2.94134 m
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.261344 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 4891
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052566
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052566
PSet_Revit_Identity Data - Mark: 4892
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.53758 m; Section: 471; Area: 0.373368 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.985 m; Start Offset: 2.985 m; End Offset: 2.985 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 2.97117 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052599
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052599
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.68 m; Start Offset: 2.68 m; End Offset: 2.94134 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 4894
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.25 m; Section: 466; Area: 0.0123155 m2
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.261344 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052601
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052601
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 2.83466 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.53758 m; Section: 918; Area: 0.356214 m2
PSet_Revit_Identity Data - Mark: 4895
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.985 m; Start Offset: 2.985 m; End Offset: 2.985 m; Slope: 0
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052632
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052632
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.261344 m
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.25 m; Section: 464; Area: 0.0123155 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.68 m; Start Offset: 2.68 m; End Offset: 2.94134 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 4897
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052634
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052634
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.985 m; Start Offset: 2.985 m; End Offset: 2.985 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.53758 m; Section: 917; Area: 0.421851 m2
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 3.35699 m
PSet_Revit_Identity Data - Mark: 4898
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052667
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052667
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.68 m; Start Offset: 2.68 m; End Offset: 2.94134 m
PSet_Revit_Identity Data - Mark: 4900
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.25 m; Section: 462; Area: 0.0123155 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.261344 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052669
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052669
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.985 m; Start Offset: 2.985 m; End Offset: 2.985 m; Slope: 0
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.53758 m; Section: 916; Area: 0.29007 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 4901
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 2.3083 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052675
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052675
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.53758 m; Section: 1322; Area: 0.210418 m2
PSet_Revit_Identity Data - Mark: 4902
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 1.67446 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.985 m; Start Offset: 2.985 m; End Offset: 2.985 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052702
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052702
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.68 m; Start Offset: 2.68 m; End Offset: 2.94134 m
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.261344 m
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.25 m; Section: 458; Area: 0.0123155 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 4903
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052710
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052710
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 4905
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.53758 m; Section: 1326; Area: 0.0772117 m2
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 0.614431 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.985 m; Start Offset: 2.985 m; End Offset: 2.985 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052717
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052717
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.141344 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.8 m; Start Offset: 2.8 m; End Offset: 2.94134 m
PSet_Revit_Identity Data - Mark: 4906
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Insulation Thickness: 0; Invert Elevation: 7.37 m; Section: 460; Area: 0.00666067 m2
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Fire Protection:1052726
In: Level 2
Type - ElementType: Pipe Types:Fire Protection:1052726
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 4908
