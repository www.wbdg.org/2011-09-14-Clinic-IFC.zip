Properties of the parts of a building model (IFC2X3), part 16 of 295

# IfcFlowFitting: 45 Degree (707)
Name | In | Length 2 | Length 1 | Mark | System Type | System Name | ASHRAE Table | Level | Host | Offset (m) | Size | OffsetHeight | OffsetWidth | Num8 | Num7 | Num6 | Num5 | Num4 | Num3 | Num2 | Num1 | PSet_Revit_Other, Delta 2 | PSet_Revit_Other, Delta 1 | WidthOffset | WidthDelta | Width2 = Lining Width 2 = Insulation Width 2 | Width1 = Lining Width 1 = Insulation Width 1 | MaxDelta = Length 01 = Computed Length | Lining Height 2 = Insulation Height 2 = Height2 | Lining Height 1 = Insulation Height 1 = Height1 | HeightOffset | HeightDelta | Half Width 2 | Half Width 1 | Half Height 2 | Half Height 1
M_Rectangular Transition - Angle:45 Degree:45 Degree:568034 | 1AC4 | 0.198016 | 0.198016 | 4023 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -0.860475 | 200x250-250x200 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.656168 | 0.82021 | 0.198016 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.328084 | 0.410105 | 0.410105 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:568101 | 1C19 | 0.396032 | 0.198016 | 4174 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.31048 | 250x200-150x250 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.246063 | 0.410105 | 0.410105 | 0.328084
M_Round Transition - Angle:45 Degree:45 Degree:1119340 | 1D16 | 0.082021 | 0.082021 | 955 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 1 | Level : Level 1 | 3.2 | 250ø-200ø | 0.328084 | 0.328084 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0273403; OffsetHeightTemp: 0.0273403; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.410105; R0: 0.328084; Lining Radius 1: 0.410105; Lining Radius 0: 0.328084; Insulation Radius 1: 0.410105; Insulation Radius 0: 0.328084; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular Transition - Angle:45 Degree:45 Degree:567746 | 1DC8 | 0.495041 | 0.396032 | 3003 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.30952 | 425x350-300x250 | 0.574311 | 0.697178 | 2 | 4 | 1.998 | 2.002 | 2.5 | 6.25 | 2.5 | 2.5 | 0.000164042 | 0 | 10 | 0.410105 | 0.984252 | 1.39436 | 0.495041 | 0.82021 | 1.14829 | 10.0002 | 0.328084 | 0.492126 | 0.697178 | 0.410105 | 0.574147
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568013 | 1A08 | 0.164042 | 0.164042 | 3938 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:567382 | 1E04 | 0.297024 | 0.198016 | 1822 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.30955 | 275x250-200x250 | 0.378773 | 0.451115 | 1 | 1 | 1 | 1 | 1.5 | 2.25 | 1.5 | 1.5 | 0.031332 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.297024 | 0.82021 | 0.82021 | 9.96867 | 0 | 0.328084 | 0.451115 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:570098 | 2B24 | 0.594049 | 0.198016 | 8595 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-150x350 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.574147 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570688 | 1A16 | 0.198016 | 0.396032 | 491 | Return Air | Mechanical Return Air 1 |  | Level 2 | Level : Level 2 | -0.93 | 550x350-550x250 | 0.574147 | 0.902231 | 2 | 4 | 2 | 2 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.80446 | 1.80446 | 0.396032 | 0.82021 | 1.14829 | 10 | 0.328084 | 0.902231 | 0.902231 | 0.410105 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:570135 | 2B10 | 0.198016 | 0.594049 | 8631 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:1119222 | 1C01 | 0.297024 | 0.198016 | 925 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.70953 | 275x250-200x250 | 0.409941 | 0.451115 | 1 | 1 | 1 | 1 | 1.5 | 2.25 | 1.5 | 1.5 | 0.000164042 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.297024 | 0.82021 | 0.82021 | 9.99984 | 0 | 0.328084 | 0.451115 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:567868 | 1E23 | 0.198016 | 0.198016 | 3381 | Supply Air | Mechanical Supply Air 1 |  | Level 1 | Level : Level 1 | 3.40951 | 150x250-150x200 | 0.410058 | 0.246063 | 1 | 1 | 0.999421 | 1.00058 | 1 | 1 | 1 | 1 | 0.0000474772 | 1.06946e-09 | 10 | 0 | 0.492126 | 0.492126 | 0.198016 | 0.656168 | 0.82021 | 9.99995 | 0.164042 | 0.246063 | 0.246063 | 0.328084 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:570654 | 1AC2 | 2.17818 | 0.594049 | 371 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.545 | 800x300-250x150 | 0.492126 | 1.31234 | 3 | 9 | 3 | 3 | 11 | 121 | 11 | 11 | 0 | 0 | 10 | 1.80446 | 0.82021 | 2.62467 | 2.17818 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 1.31234 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569093 | 2AC1 | 0.396032 | 0.198016 | 6001 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.73 | 650x400-550x400 | 0.656168 | 1.06627 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 1.80446 | 2.13255 | 0.396032 | 1.31234 | 1.31234 | 10 | 0 | 0.902231 | 1.06627 | 0.656168 | 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:1138598 | 1B04 | 0.198016 | 0.792065 | 1483 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.3 | 200x250-200x50 | 0.410105 | 0.328084 | 4 | 16 | 4 | 4 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.656168 | 0.656168 | 0.792065 | 0.164042 | 0.82021 | 10 | 0.656168 | 0.328084 | 0.328084 | 0.082021 | 0.410105
M_Round Transition - Angle:45 Degree:45 Degree:567798 | 1DC7 | 0.082021 | 0.082021 | 3153 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 1 | Level : Level 1 | 3.3095 | 200ø-150ø | 0.328084 | 0.328084 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 1.27898e-13; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0273403; OffsetHeightTemp: 0.0273403; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.246063; R0: 0.328084; Lining Radius 1: 0.246063; Lining Radius 0: 0.328084; Insulation Radius 1: 0.246063; Insulation Radius 0: 0.328084; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular Transition - Angle:45 Degree:45 Degree:566858 | 1B08 | 0.198016 | 0.198016 | 713 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.3 | 350x200-350x150 | 0.328084 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.574147 | 0.574147 | 0.246063 | 0.328084
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567785 | 1D36 | 0 | 0 | 3127 | Supply Air | Mechanical Supply Air 1 | SD4-2 | Level 1 | Level : Level 1 | 3.3096 | 150x250-150ø | 0.410105 | 0.246063 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 0; Length 8: 0; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.410105; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.246063; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0; W0: 0.492126; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.492126; Lining Radius: 0.246063; Lining H0: 0.82021; Length01: 0.396032; Insulation W0: 0.492126; Insulation Radius: 0.246063; Insulation H0: 0.82021; H0: 0.82021; OffsetWidthTemp: -0.0208333; OffsetHeightTemp: 0.0347222; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570010 | 2D10 | 0.198016 | 0.594049 | 8393 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568107 | 1C14 | 0.396032 | 0.198016 | 4196 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.2605 | 250x300-150x300 | 0.492126 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.984252 | 0.984252 | 10 | 0 | 0.246063 | 0.410105 | 0.492126 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570589 | 1A16 | 0.198016 | 0.198016 | 148 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.27 | 300x250-250x250 | 0.410105 | 0.410105 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.984252 | 0.82021 | 0.198016 | 0.82021 | 0.82021 | 10 | 0 | 0.492126 | 0.410105 | 0.410105 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568594 | 1D16 | 0.246063 | 0.246063 | 5455 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570674 | 1A02 | 3.76231 | 0.594049 | 448 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.454 | 1200x300-250x150 | 0.492126 | 1.9685 | 3 | 9 | 3 | 3 | 19 | 361 | 19 | 19 | 0 | 0 | 10 | 3.1168 | 0.82021 | 3.93701 | 3.76231 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 1.9685 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:1138729 | 1B03 | 0.198016 | 0.594049 | 1516 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.3 | 250x300-250x150 | 0.492126 | 0.410105 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.82021 | 0.82021 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 0.410105 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:1138843 | 1A16 | 0.198016 | 0.396032 | 1544 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -1.325 | 250x250-250x150 | 0.410105 | 0.410105 | 2 | 4 | 2 | 2 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.82021 | 0.82021 | 0.396032 | 0.492126 | 0.82021 | 10 | 0.328084 | 0.410105 | 0.410105 | 0.246063 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:570690 | 1A16 | 0.0990081 | 0.792065 | 494 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.70953 | 475x450-450x250 | 0.738189 | 0.779199 | 4 | 16 | 4 | 4 | 0.5 | 0.25 | 0.5 | 0.5 | 0 | 0 | 10 | 0.082021 | 1.47638 | 1.5584 | 0.792065 | 0.82021 | 1.47638 | 10 | 0.656168 | 0.738189 | 0.779199 | 0.410105 | 0.738189
M_Rectangular Transition - Angle:45 Degree:45 Degree:569117 | 2A03 | 0.594049 | 0.396032 | 6082 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.66893 | 300x300-150x400 | 0.492126 | 0.492126 | 2 | 4 | 2 | 2 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.31234 | 0.984252 | 10 | 0.328084 | 0.246063 | 0.492126 | 0.656168 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569285 | 2C01 | 0.198016 | 0.198016 | 6465 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07048 | 350x300-300x250 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.984252 | 1.14829 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.492126 | 0.574147 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:1118930 | 1D38 | 0.198016 | 0.594049 | 896 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.11893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Round Transition - Angle:45 Degree:45 Degree:568032 | Level 1 | 0.082021 | 0.082021 | 4022 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 2 | Level : Level 2 | -0.87 | 200ø-150ø | 0.328084 | 0.328084 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0273403; OffsetHeightTemp: 0.0273403; WidthOffsetfromBase: 10; Offest Delta: 2.66454e-14; DiameterDelta: 0.082021; R1: 0.246063; R0: 0.328084; Lining Radius 1: 0.246063; Lining Radius 0: 0.328084; Insulation Radius 1: 0.246063; Insulation Radius 0: 0.328084; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Round Transition - Angle:45 Degree:45 Degree:568114 | 1C18 | 0.163994 | 0.16409 | 4244 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 2 | Level : Level 2 | -1.32 | 300ø-200ø | 0.492124 | 0.492078 | PSet_Revit_Other - Num 1: 1.96908; Num 5: 4.75239; Num 4: 1; Num 3: 3.93701; Num 2: 1.96793; Length 3: 0.0000481819; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0410065; OffsetHeightTemp: 0.0410103; WidthOffsetfromBase: 9.99995; Offest Delta: -0.00000185315; DiameterDelta: 0.164042; R1: 0.328084; R0: 0.492126; Lining Radius 1: 0.328084; Lining Radius 0: 0.492126; Insulation Radius 1: 0.328084; Insulation Radius 0: 0.492126; HeightOffsetfromBase: 10; ComputedLength: 0.396032
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568686 | 1E16 | 0.246063 | 0.246063 | 5515 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570059 | 2BC3 | 0.198016 | 0.396032 | 8510 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.68 | 400x250-400x150 | 0.246063 | 0.656168 | 2 | 4 | 2 | 2 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.31234 | 1.31234 | 0.396032 | 0.82021 | 0.492126 | 10 | 0.328084 | 0.656168 | 0.656168 | 0.410105 | 0.246063
M_Rectangular Transition - Angle:45 Degree:45 Degree:570104 | 2B01 | 0.594049 | 0.198016 | 8600 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-150x350 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.574147 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570083 | 2B22 | 0.198016 | 0.198016 | 8583 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.68 | 350x200-350x150 | 0.328084 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.574147 | 0.574147 | 0.246063 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:568026 | 1AC3 | 0.594049 | 0.198016 | 3989 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -0.83545 | 350x300-200x300 | 0.491962 | 0.574147 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0.000164042 | 0 | 10 | 0.492126 | 0.656168 | 1.14829 | 0.594049 | 0.984252 | 0.984252 | 9.99984 | 0 | 0.328084 | 0.574147 | 0.492126 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568103 | 1C14 | 0.396032 | 0.198016 | 4180 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.26048 | 350x300-250x300 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.82021 | 1.14829 | 0.396032 | 0.984252 | 0.984252 | 10 | 0 | 0.410105 | 0.574147 | 0.492126 | 0.492126
M_Round Transition - Angle:45 Degree:45 Degree:568024 | 1AC3 | 0.0792323 | 0.0848097 | 3986 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 2 | Level : Level 2 | -0.87 | 250ø-200ø | 0.410187 | 0.330873 | PSet_Revit_Other - Num 1: 1.01772; Num 5: 2.37579; Num 4: 1; Num 3: 1.9685; Num 2: 0.950787; Length 3: 0.00278871; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0275727; OffsetHeightTemp: 0.0341823; WidthOffsetfromBase: 10.0028; Offest Delta: 0.082103; DiameterDelta: 0.082021; R1: 0.410105; R0: 0.328084; Lining Radius 1: 0.410105; Lining Radius 0: 0.328084; Insulation Radius 1: 0.410105; Insulation Radius 0: 0.328084; HeightOffsetfromBase: 9.9179; ComputedLength: 0.197983
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:1137516 | 1D09 | 0.082021 | 0.082021 | 1319 | Supply Air | Mechanical Supply Air 1 | SD4-2 | Level 1 | Level : Level 1 | 3.3095 | 250x250-200ø | 0.410105 | 0.410105 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.410105; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.410105; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.82021; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.82021; Lining Radius: 0.328084; Lining H0: 0.82021; Length01: 0.198016; Insulation W0: 0.82021; Insulation Radius: 0.328084; Insulation H0: 0.82021; H0: 0.82021; OffsetWidthTemp: -0.0347222; OffsetHeightTemp: 0.0347222; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:570087 | 2B21 | 0.594049 | 0.198016 | 8586 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-150x350 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.574147 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:1090601 | 1E14 | 0.198016 | 0.396032 | 238 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.755 | 350x250-350x150 | 0.410105 | 0.574147 | 2 | 4 | 2 | 2 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.396032 | 0.492126 | 0.82021 | 10 | 0.328084 | 0.574147 | 0.574147 | 0.246063 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:570645 | 1DC2 | 0.198016 | 0.396032 | 337 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.70953 | 250x300-250x200 | 0.328084 | 0.410105 | 2 | 4 | 2 | 2 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.82021 | 0.82021 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.410105 | 0.410105 | 0.492126 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:1124504 | 1E24 | 0.82021 | 0.198016 | 1287 | Return Air | Mechanical Return Air 1 |  | Level 1 | Level : Level 1 | 3.79 | 750x300-500x300 | 0.492126 | 1.64042 | 1 | 1 | 1 | 1 | 5 | 25 | -7.58007e-14 | 10 | 0 | 0.410105 | 10.4101 | 0.82021 | 1.64042 | 2.46063 | 0.82021 | 0.984252 | 0.984252 | 10 | 0 | 0.82021 | 1.23031 | 0.492126 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567862 | 1E23 | 0.0990081 | 0.198016 | 3370 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.40952 | 300x250-275x250 | 0.410105 | 0.451115 | 1 | 1 | 1 | 1 | 0.5 | 0.25 | 0.5 | 0.5 | 0 | 0 | 10 | 0.082021 | 0.984252 | 0.902231 | 0.0990081 | 0.82021 | 0.82021 | 10 | 0 | 0.492126 | 0.451115 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:567897 | 1CC1 | 0.198016 | 0.594049 | 3445 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.93 | 350x350-350x200 | 0.574147 | 0.574147 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.594049 | 0.656168 | 1.14829 | 10 | 0.492126 | 0.574147 | 0.574147 | 0.328084 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:570795 | 1B19 | 0.198016 | 0.198016 | 730 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.79 | 350x300-300x300 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.984252 | 1.14829 | 0.198016 | 0.984252 | 0.984252 | 10 | 0 | 0.492126 | 0.574147 | 0.492126 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:1099779 | 1C18 | 0.0990081 | 0.198016 | 387 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.25952 | 275x250-250x250 | 0.409941 | 0.451115 | 1 | 1 | 1 | 1 | 0.5 | 0.25 | 0.5 | 0.5 | 0.000164042 | 0 | 10 | 0.082021 | 0.82021 | 0.902231 | 0.0990081 | 0.82021 | 0.82021 | 9.99984 | 0 | 0.410105 | 0.451115 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:570652 | 1AC2 | 2.17818 | 0.594049 | 363 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.545 | 800x300-250x150 | 0.492126 | 1.31234 | 3 | 9 | 3 | 3 | 11 | 121 | 11 | 11 | 0 | 0 | 10 | 1.80446 | 0.82021 | 2.62467 | 2.17818 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 1.31234 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:1105139 | 2B3 | 0.495041 | 0.396032 | 451 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Level 2 | Level : Level 2 | 3.60955 | 275x250-150x350 | 0.409941 | 0.451115 | 2 | 4 | 1.998 | 2.002 | 2.5 | 6.25 | 2.5 | 2.5 | 0.000164042 | 0 | 10 | 0.410105 | 0.492126 | 0.902231 | 0.495041 | 1.14829 | 0.82021 | 9.99984 | 0.328084 | 0.246063 | 0.451115 | 0.574147 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:568126 | 1C18 | 0.396032 | 0.198016 | 4278 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.31048 | 250x200-150x250 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.246063 | 0.410105 | 0.410105 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:570093 | 2B23 | 0.594049 | 0.198016 | 8591 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-150x350 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.574147 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:1100898 | 1D25 | 0.164042 | 0.164042 | 399 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168

# IfcFlowFitting: 60 Degree, M_Rectangular Transition - Angle:60 Degree:60 Degree:1111203
In: 1D01
Type - ElementType: 60 Degree
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Constraints - Angle: 60 deg
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 496
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Dimensions - WidthOffset: 10; WidthDelta: 1.9685; Width2: 0.656168; Width1: 2.62467; MaxDelta: 1.70477; Lining Width 2: 0.656168; Lining Width 1: 2.62467; Lining Height 2: 0.82021; Lining Height 1: 0.984252; Length 01: 1.70477; Insulation Width 2: 0.656168; Insulation Width 1: 2.62467; Insulation Height 2: 0.82021; Insulation Height 1: 0.984252; HeightOffset: 10; HeightDelta: 0.164042; Height2: 0.82021; Height1: 0.984252; Half Width 2: 0.328084; Half Width 1: 1.31234; Half Height 2: 0.410105; Half Height 1: 0.492126; Computed Length: 1.70477; Size: 800x300-200x250; OffsetHeight: 0.492126; OffsetWidth: 1.31234
PSet_Revit_Other - Num8: 0.57735; Num7: 0.333333; Num6: 1; Num5: 1; Num4: 6.9282; Num3: 48; Num2: 12; Num1: 12; Length 2: 1.70477; Length 1: 0.142065; Delta 2: 0; Delta 1: 0; TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Level: Level 1; Host: Level : Level 1; Offset: 3.545 m
PSet_Revit_Mechanical - Lining Thickness: 0; Insulation Thickness: 0; System Type: Supply Air; System Name: Default Supply Air (cskender); ASHRAE Table: SR4-1; Loss Method: 1

# IfcFlowFitting: Cross - Generic (41)
Type - ElementType: Cross - Generic
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Insulation Thickness: 0; Loss Method: 5
PSet_Revit_Other - Angle 5: 90 deg; Angle 4: 90 deg; Angle 3: 90 deg; TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Angle 2: 90 deg; Angle 1: 90 deg
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Type_Mechanical - Loss Method: 0
PSet_Revit_Type_Other - Lookup Table Name: M_Pipe Fitting - Generic.csv; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.60.30.11.14; OmniClass Title: Pipework Fittings
Name (M_Cross - Generic:Cross - Generic:Cross - Generic:...) | In | Level | Host | Offset (m) | System Type | System Name | Center to End Label = Center to End | Fitting Outside Radius = Insulation Radius | Tick Size | Nominal Radius | Nominal Diameter | Fitting Outside Diameter | Size | Mark
667299 | Level 2 | Level 2 | Level : Level 2 | 0.232932 | Sanitary | Sanitary 1 | 0.213542 | 0.171875 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 100 mmø-100 mmø-100 mmø-100 mmø | 4763
1001246 | Level 1 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.109375 | 0.0677083 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 40 mmø-40 mmø-40 mmø-40 mmø | 10137
1029175 | 2AC2 | Level 2 | Level : Level 2 | 2.985 | Fire Protection Wet | Fire Protection | 0.171875 | 0.130208 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 80 mmø-80 mmø-80 mmø-80 mmø | 11734
678338 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | Domestic Cold Water | Domestic Cold Water 1 | 0.0989583 | 0.0572917 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 32 mmø-32 mmø-32 mmø-32 mmø | 4943
1001232 | Level 1 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.109375 | 0.0677083 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 40 mmø-40 mmø-40 mmø-40 mmø | 10136
1001183 | 1E24 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.109375 | 0.0677083 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 40 mmø-40 mmø-40 mmø-40 mmø | 10133
1001197 | 1EC4 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.109375 | 0.0677083 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 40 mmø-40 mmø-40 mmø-40 mmø | 10134
1030830 | 2D05 | Level 2 | Level : Level 2 | 2.985 | Fire Protection Wet | Fire Protection | 0.171875 | 0.130208 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 80 mmø-80 mmø-80 mmø-80 mmø | 11865
1030919 | 2CC5 | Level 2 | Level : Level 2 | 2.985 | Fire Protection Wet | Fire Protection | 0.171875 | 0.130208 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 80 mmø-80 mmø-80 mmø-80 mmø | 11874
1002133 | 1DC6 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.296875 | 0.255208 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 150 mmø-150 mmø-150 mmø-150 mmø | 10210
1030194 | 2D18 | Level 2 | Level : Level 2 | 2.985 | Fire Protection Wet | Fire Protection | 0.171875 | 0.130208 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 80 mmø-80 mmø-80 mmø-80 mmø | 11838
1002027 | Level 1 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.296875 | 0.255208 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 150 mmø-150 mmø-150 mmø-150 mmø | 10205
1029990 | 2D02 | Level 2 | Level : Level 2 | 2.985 | Fire Protection Wet | Fire Protection | 0.109375 | 0.0677083 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 40 mmø-40 mmø-40 mmø-40 mmø | 11801
1030797 | 2D05 | Level 2 | Level : Level 2 | 2.985 | Fire Protection Wet | Fire Protection | 0.171875 | 0.130208 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 80 mmø-80 mmø-80 mmø-80 mmø | 11862
1001674 | 1B03 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.109375 | 0.0677083 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 40 mmø-40 mmø-40 mmø-40 mmø | 10168
1030947 | 2C13 | Level 2 | Level : Level 2 | 2.985 | Fire Protection Wet | Fire Protection | 0.171875 | 0.130208 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 80 mmø-80 mmø-80 mmø-80 mmø | 11877
1030903 | 2C12 | Level 2 | Level : Level 2 | 2.985 | Fire Protection Wet | Fire Protection | 0.171875 | 0.130208 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 80 mmø-80 mmø-80 mmø-80 mmø | 11871
1001106 | 1E26 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.109375 | 0.0677083 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 40 mmø-40 mmø-40 mmø-40 mmø | 10123
1030253 | 2D07 | Level 2 | Level : Level 2 | 2.985 | Fire Protection Wet | Fire Protection | 0.171875 | 0.130208 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 80 mmø-80 mmø-80 mmø-80 mmø | 11844
1030383 | 2D05 | Level 2 | Level : Level 2 | 2.985 | Fire Protection Wet | Fire Protection | 0.171875 | 0.130208 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 80 mmø-80 mmø-80 mmø-80 mmø | 11856
1030269 | 2D05 | Level 2 | Level : Level 2 | 2.985 | Fire Protection Wet | Fire Protection | 0.171875 | 0.130208 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 80 mmø-80 mmø-80 mmø-80 mmø | 11847
692404 | Level 1 | Level 2 | Level : Level 2 | -0.411 | Sanitary | Default Sanitary (cskender) | 0.213542 | 0.171875 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 100 mmø-100 mmø-100 mmø-100 mmø | 6506
1030866 | 2C19 | Level 2 | Level : Level 2 | 2.985 | Fire Protection Wet | Fire Protection | 0.171875 | 0.130208 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 80 mmø-80 mmø-80 mmø-80 mmø | 11868
1025936 | Level 1 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.296875 | 0.255208 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 150 mmø-150 mmø-150 mmø-150 mmø | 11073
1001650 | 1B19 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.109375 | 0.0677083 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 40 mmø-40 mmø-40 mmø-40 mmø | 10166
1001118 | 1EC2 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.109375 | 0.0677083 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 40 mmø-40 mmø-40 mmø-40 mmø | 10124
1118859 | 1EC1 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.296875 | 0.255208 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 150 mmø-150 mmø-150 mmø-150 mmø | 15161
1001963 | 1EC3 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.296875 | 0.255208 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 150 mmø-150 mmø-150 mmø-150 mmø | 10202
1030354 | 2D05 | Level 2 | Level : Level 2 | 2.985 | Fire Protection Wet | Fire Protection | 0.171875 | 0.130208 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 80 mmø-80 mmø-80 mmø-80 mmø | 11853
1026126 | 1B23 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.109375 | 0.0677083 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 40 mmø-40 mmø-40 mmø-40 mmø | 11080
1001660 | 1B13 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.109375 | 0.0677083 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 40 mmø-40 mmø-40 mmø-40 mmø | 10167
1030225 | 2D18 | Level 2 | Level : Level 2 | 2.985 | Fire Protection Wet | Fire Protection | 0.171875 | 0.130208 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 80 mmø-80 mmø-80 mmø-80 mmø | 11841
657219 | 1B04 | Level 1 | Level : Level 1 | 3.1 | Sanitary | Default Sanitary (cskender) | 0.130208 | 0.0885417 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 50 mmø-50 mmø-50 mmø-50 mmø | 3617
1018426 | 1AC3 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.296875 | 0.255208 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 150 mmø-150 mmø-150 mmø-150 mmø | 11052
1030413 | 2D05 | Level 2 | Level : Level 2 | 2.985 | Fire Protection Wet | Fire Protection | 0.171875 | 0.130208 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 80 mmø-80 mmø-80 mmø-80 mmø | 11859
1030317 | 2D05 | Level 2 | Level : Level 2 | 2.985 | Fire Protection Wet | Fire Protection | 0.171875 | 0.130208 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 80 mmø-80 mmø-80 mmø-80 mmø | 11850
1002400 | 1D14 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.109375 | 0.0677083 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 40 mmø-40 mmø-40 mmø-40 mmø | 10244
1002606 | 1CC1 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.296875 | 0.255208 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 150 mmø-150 mmø-150 mmø-150 mmø | 10265
1025354 | 1EC1 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.296875 | 0.255208 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 150 mmø-150 mmø-150 mmø-150 mmø | 11070
1029978 | 2BC1 | Level 2 | Level : Level 2 | 2.98519 | Fire Protection Wet | Fire Protection | 0.171875 | 0.130208 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 80 mmø-80 mmø-80 mmø-80 mmø | 11798
1002649 | 1CC3 | Level 1 | Level : Level 1 | 2.985 | Fire Protection Wet | Fire Protection | 0.296875 | 0.255208 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 150 mmø-150 mmø-150 mmø-150 mmø | 10272

# IfcFlowFitting: Elbow - Generic (2063)
Type - ElementType: Elbow - Generic
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Mechanical - Insulation Thickness: 0; Loss Method: 5; K Coefficient Table: Regular 45, 90 and 180 Elbow
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.60.30.11.14; OmniClass Title: Pipework Fittings
PSet_Revit_Type_Other - Lookup Table Name: M_Pipe Fitting - Generic.csv; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - Loss Method: 1; K Coefficient Table: Regular 45, 90 and 180 Elbow
Name (M_Elbow - Generic:Elbow - Generic:Elbow - Generic:...) | In | Level | Host | Offset (m) | Mark | Tick Size | Nominal Radius | Nominal Diameter | Insulation Radius = Fitting Outside Radius | Fitting Outside Diameter | Center to End | Angle (deg) | Size | Center Radius | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | System Type | System Name
646736 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 3121 | 0.0293401 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0453046 | 45 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
655208 | Level 1 | Level 1 | Level : Level 1 | 4.159 | 3411 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
654927 | 1B05 | Level 2 | Level : Level 2 | -0.2 | 3387 | 0.0403377 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0622862 | 59.3208 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
664551 | Level 2 | Level 2 | Level : Level 2 | 2.9 | 4449 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
645873 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 2986 | 0.0355586 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.0606113 | 75.6104 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
664319 | 1D07 | Level 2 | Level : Level 2 | -1.4 | 4401 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
681269 | Level 1 | Level 1 | Level : Level 1 | 0.688244 | 5207 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
655272 | 1B05 | Level 2 | Level : Level 2 | -0.411 | 3417 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
659374 | 2C17 | Level 2 | Level : Level 2 | 3.1 | 3809 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
662500 | 2A09 | Level 2 | Level : Level 2 | 2.9 | 4214 | 0.0333051 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.051427 | 50.3648 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
667386 | 1D08 | Level 1 | Level : Level 1 | 2.9 | 4772 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
678957 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 4978 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
653979 | 1B04 | Level 2 | Level : Level 2 | -0.411 | 3308 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
690463 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 6287 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
690548 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 6299 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
685684 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5709 | 0.0875 | 0.106627 | 0.213255 | 0.109375 | 0.21875 | 0.130208 | 90 | 65 mmø-65 mmø | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
726385 | 1A01 | Level 2 | Level : Level 2 | -0.444 | 9925 | 0.0542257 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.0786273 | 55 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Storm
655309 | 1B05 | Level 2 | Level : Level 2 | -0.411 | 3418 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
666605 | Level 1 | Level 2 | Level : Level 2 | -1.56 | 4656 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
645546 | 1D10 | Level 1 | Level : Level 1 | 2.9 | 2920 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
664530 | Level 2 | Level 1 | Level : Level 1 | 5.07 | 4447 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
645740 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 2945 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
687977 | Level 1 | Level 1 | Level : Level 1 | 0.806263 | 5987 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
645871 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 2984 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
679491 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5045 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
655790 | 1E12 | Level 2 | Level : Level 2 | -1.6882 | 3482 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
659578 | 1DC4 | Level 2 | Level : Level 2 | -1.6882 | 3822 | 0.0431472 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.0625635 | 45 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
645566 | 1D08 | Level 1 | Level : Level 1 | 2.9 | 2926 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
666097 | Level 1 | Level 2 | Level : Level 2 | -1.6882 | 4584 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
679597 | 1B02 | Level 1 | Level : Level 1 | 0.371263 | 5066 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
645402 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 2910 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
690892 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 6329 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
679596 | 1B02 | Level 1 | Level : Level 1 | 0.371263 | 5065 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
655170 | Level 1 | Level 1 | Level : Level 1 | 0 | 3407 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
690767 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 6317 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
692004 | 1B03 | Level 2 | Level : Level 2 | -1.5 | 6451 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
681507 | Level 1 | Level 1 | Level : Level 1 | 0.806263 | 5247 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
658739 | 1D11 | Level 2 | Level : Level 2 | -1.6882 | 3741 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
664468 | 1D05 | Level 2 | Level : Level 2 | -1.6882 | 4434 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
655432 | 1B07 | Level 2 | Level : Level 2 | -0.411 | 3436 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
664639 | 2AC2 | Level 2 | Level : Level 2 | 2.9 | 4462 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
681560 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5260 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
691348 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 6423 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
659650 | 1D16 | Level 2 | Level : Level 2 | -1.6882 | 3824 | 0.0293401 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0453046 | 45 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
662370 | 2A09 | Level 1 | Level : Level 1 | 7.47 | 4200 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
692048 | 1B03 | Level 2 | Level : Level 2 | -1.5 | 6452 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
691175 | Level 1 | Level 1 | Level : Level 1 | 0.371263 | 6387 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
666702 | Level 2 | Level 1 | Level : Level 1 | 7.47 | 4680 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
726796 | Level 2 | Level 1 | Level : Level 1 | 4.87 | 9947 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Storm
666494 | 1D07 | Level 2 | Level : Level 2 | -1.56 | 4638 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
690915 | Level 1 | Level 1 | Level : Level 1 | 0.688244 | 6335 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
659752 | 1D16 | Level 2 | Level : Level 2 | -1.6882 | 3843 | 0.0293401 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0453046 | 45 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
646399 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 3068 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
681270 | Level 1 | Level 1 | Level : Level 1 | 0.688244 | 5208 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
691019 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 6362 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
685699 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5714 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
662893 | Level 2 | Level 2 | Level : Level 2 | 3 | 4267 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
691134 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 6383 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
998266 | 2D05 | Level 2 | Level : Level 2 | 3.6 | 10019 | 0.0375 | 0.082021 | 0.164042 | 0.046875 | 0.09375 | 0.0677083 | 90 | 50 mmø-50 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
667066 | 2C07 | Level 2 | Level : Level 2 | 2.9 | 4735 | 0.0224366 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0366752 | 45 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
726247 | Level 1 | Level 2 | Level : Level 2 | -4.27 | 9914 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Storm
646923 | Level 1 | Level 1 | Level : Level 1 | 2.9 | 3137 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1056719 | 1D20 | Level 2 | Level : Level 2 | -1.35 | 13434 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
687943 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5983 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
646636 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 3113 | 0.018938 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0309563 | 38.5417 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
645742 | Level 1 | Level 1 | Level : Level 1 | 2.9 | 2947 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
687767 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5962 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
691052 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 6365 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
690916 | Level 1 | Level 1 | Level : Level 1 | 0.688244 | 6336 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
680114 | Level 1 | Level 1 | Level : Level 1 | 0.371263 | 5100 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
687261 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5894 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
