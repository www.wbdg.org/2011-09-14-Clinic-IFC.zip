Properties of the parts of a building model (IFC2X3), part 237 of 295

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569926
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569927
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569927
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1757
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.725 m; Top Elevation: 4.075 m; Equivalent Diameter: 1.62886; Size Lock: no; Loss Coefficient: 0.161108; Hydraulic Diameter: 1.45048; Section: 88; Insulation Thickness: 0; Lining Thickness: 0; Area: 9.23871 m2
PSet_Revit_Mechanical - Airflow - Flow: 66.3916; Additional Flow: 0; Velocity: 29.3713; Friction: 0.14834; Pressure Drop: 2.36646; Velocity Pressure: 14.6887; Reynolds number: 263720
PSet_Revit_Dimensions - Size: 600x350; Width: 1.9685; Height: 1.14829; Length: 4.86248 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.9 m; Start Offset: 3.9 m; End Offset: 3.9 m; Slope: 0
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569928
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569928
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.725 m; Top Elevation: 4.075 m; Equivalent Diameter: 1.62886; Size Lock: no; Loss Coefficient: 0.0160814; Hydraulic Diameter: 1.45048; Section: 95; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.869725 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1758
PSet_Revit_Mechanical - Airflow - Flow: 49.7937; Additional Flow: 0; Velocity: 22.0285; Friction: 0.0884739; Pressure Drop: 0.13287; Velocity Pressure: 8.26239; Reynolds number: 197790
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.9 m; Start Offset: 3.9 m; End Offset: 3.9 m; Slope: 0
PSet_Revit_Dimensions - Size: 600x350; Width: 1.9685; Height: 1.14829; Length: 0.45775 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569930
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569930
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 500x350; Width: 1.64042; Height: 1.14829; Length: 3.97929 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.9 m; Start Offset: 3.9 m; End Offset: 3.9 m; Slope: 0
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.725 m; Top Elevation: 4.075 m; Equivalent Diameter: 1.49442; Size Lock: no; Loss Coefficient: 0.146724; Hydraulic Diameter: 1.35093; Section: 94; Insulation Thickness: 0; Lining Thickness: 0; Area: 6.76479 m2
PSet_Revit_Mechanical - Airflow - Flow: 49.7937; Additional Flow: 0; Velocity: 26.4342; Friction: 0.133715; Pressure Drop: 1.7457; Velocity Pressure: 11.8978; Reynolds number: 221060
PSet_Revit_Identity Data - Mark: 1759
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569932
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569932
PSet_Revit_Mechanical - Airflow - Flow: 33.1958; Additional Flow: 0; Velocity: 20.5599; Friction: 0.0953417; Pressure Drop: 0.39376; Velocity Pressure: 7.19746; Reynolds number: 156584
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.9 m; Start Offset: 3.9 m; End Offset: 3.9 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1760
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.75 m; Top Elevation: 4.05 m; Equivalent Diameter: 1.37788; Size Lock: no; Loss Coefficient: 0.0547082; Hydraulic Diameter: 1.23031; Section: 101; Insulation Thickness: 0; Lining Thickness: 0; Area: 2.01411 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 500x300; Width: 1.64042; Height: 0.984252; Length: 1.25882 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569934
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569934
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 450x300; Width: 1.47638; Height: 0.984252; Length: 2.83964 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.75 m; Top Elevation: 4.05 m; Equivalent Diameter: 1.31106; Size Lock: no; Loss Coefficient: 0.134661; Hydraulic Diameter: 1.1811; Section: 105; Insulation Thickness: 0; Lining Thickness: 0; Area: 4.25947 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.9 m; Start Offset: 3.9 m; End Offset: 3.9 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1761
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 24.8968; Additional Flow: 0; Velocity: 17.1333; Friction: 0.0722453; Pressure Drop: 0.673067; Velocity Pressure: 4.99824; Reynolds number: 125267
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569936
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569936
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.775 m; Top Elevation: 4.025 m; Equivalent Diameter: 1.19021; Size Lock: no; Loss Coefficient: 0.0627413; Hydraulic Diameter: 1.05456; Section: 109; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.54587 m2
PSet_Revit_Identity Data - Mark: 1762
PSet_Revit_Dimensions - Size: 450x250; Width: 1.47638; Height: 0.82021; Length: 1.10419 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.9 m; Start Offset: 3.9 m; End Offset: 3.9 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 16.5979; Additional Flow: 0; Velocity: 13.7066; Friction: 0.0554013; Pressure Drop: 0.200701; Velocity Pressure: 3.19887; Reynolds number: 89476.5
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569938
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569938
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.9 m; Start Offset: 3.9 m; End Offset: 3.9 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 16.5979; Additional Flow: 0; Velocity: 13.7066; Friction: 0.0554013; Pressure Drop: 0.227204; Velocity Pressure: 3.19887; Reynolds number: 89476.5
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.775 m; Top Elevation: 4.025 m; Equivalent Diameter: 1.19021; Size Lock: no; Loss Coefficient: 0.0710261; Hydraulic Diameter: 1.05456; Section: 109; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.75 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1763
PSet_Revit_Dimensions - Size: 450x250; Width: 1.47638; Height: 0.82021; Length: 1.25 m
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569940
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569940
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1764
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.9 m; Start Offset: 3.9 m; End Offset: 3.9 m; Slope: 0
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.825 m; Top Elevation: 3.975 m; Equivalent Diameter: 0.898888; Size Lock: no; Loss Coefficient: 0.260235; Hydraulic Diameter: 0.738189; Section: 112; Insulation Thickness: 0; Lining Thickness: 0; Area: 3.36215 m2
PSet_Revit_Dimensions - Size: 450x150; Width: 1.47638; Height: 0.492126; Length: 2.80179 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 11.4222; Friction: 0.0628898; Pressure Drop: 0.578097; Velocity Pressure: 2.22144; Reynolds number: 52194.6
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569942
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569942
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.825 m; Top Elevation: 3.975 m; Equivalent Diameter: 0.898888; Size Lock: no; Loss Coefficient: 0.0415091; Hydraulic Diameter: 0.738189; Section: 112; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.536283 m2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 11.4222; Friction: 0.0628898; Pressure Drop: 0.09221; Velocity Pressure: 2.22144; Reynolds number: 52194.6
PSet_Revit_Dimensions - Size: 450x150; Width: 1.47638; Height: 0.492126; Length: 0.446902 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.9 m; Start Offset: 3.9 m; End Offset: 3.9 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1765
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569943
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569943
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 2.9016 m; Top Elevation: 3.61893 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0499705; Hydraulic Diameter: 0.984252; Section: 111; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.860801 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.717334 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0624411; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1766
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.9016 m; Start Offset: 2.9016 m; End Offset: 3.61893 m
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569947
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569947
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 7.00907; Friction: 0.0192066; Pressure Drop: 0.0459938; Velocity Pressure: 0.836482; Reynolds number: 41755.7
PSet_Revit_Dimensions - Size: 550x200; Width: 1.80446; Height: 0.656168; Length: 0.729899 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1767
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 4 m; Start Offset: 4 m; End Offset: 4 m; Slope: 0
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.9 m; Top Elevation: 4.1 m; Equivalent Diameter: 1.15354; Size Lock: no; Loss Coefficient: 0.0549848; Hydraulic Diameter: 0.96238; Section: 108; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.09485 m2
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569949
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569949
PSet_Revit_Dimensions - Size: 550x200; Width: 1.80446; Height: 0.656168; Length: 0.13727 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.9 m; Top Elevation: 4.1 m; Equivalent Diameter: 1.15354; Size Lock: no; Loss Coefficient: 0.0103408; Hydraulic Diameter: 0.96238; Section: 108; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.205904 m2
PSet_Revit_Identity Data - Mark: 1768
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 4 m; Start Offset: 4 m; End Offset: 4 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 7.00907; Friction: 0.0192066; Pressure Drop: 0.00864988; Velocity Pressure: 0.836482; Reynolds number: 41755.7
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569950
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569950
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0803783; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Identity Data - Mark: 1769
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.9234 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 2.9016 m; Top Elevation: 3.825 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0643253; Hydraulic Diameter: 0.984252; Section: 107; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.10808 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.9016 m; Start Offset: 2.9016 m; End Offset: 3.825 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569954
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569954
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.925 m; Top Elevation: 4.075 m; Equivalent Diameter: 0.804054; Size Lock: no; Loss Coefficient: 0.0337542; Hydraulic Diameter: 0.688976; Section: 104; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.355 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 4 m; Start Offset: 4 m; End Offset: 4 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 350x150; Width: 1.14829; Height: 0.492126; Length: 0.355 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 14.6857; Friction: 0.106423; Pressure Drop: 0.123951; Velocity Pressure: 3.67217; Reynolds number: 62633.6
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1770
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569956
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569956
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.9016 m; Start Offset: 2.9016 m; End Offset: 3.71893 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0711457; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 2.9016 m; Top Elevation: 3.71893 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0569366; Hydraulic Diameter: 0.984252; Section: 103; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.980801 m2
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.817334 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1771
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569959
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569959
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 14.6857; Friction: 0.106423; Pressure Drop: 0.115222; Velocity Pressure: 3.67217; Reynolds number: 62633.6
PSet_Revit_Identity Data - Mark: 1772
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.925 m; Top Elevation: 4.075 m; Equivalent Diameter: 0.804054; Size Lock: no; Loss Coefficient: 0.0313771; Hydraulic Diameter: 0.688976; Section: 100; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.33 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 350x150; Width: 1.14829; Height: 0.492126; Length: 0.33 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 4 m; Start Offset: 4 m; End Offset: 4 m; Slope: 0
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569961
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569961
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.02231 m; Top Elevation: 3.71893 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0485278; Hydraulic Diameter: 0.984252; Section: 99; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.835948 m2
PSet_Revit_Identity Data - Mark: 1773
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.696623 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.02231 m; Start Offset: 3.02231 m; End Offset: 3.71893 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0606383; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569964
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569964
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.925 m; Top Elevation: 4.075 m; Equivalent Diameter: 0.804054; Size Lock: no; Loss Coefficient: 0.0313771; Hydraulic Diameter: 0.688976; Section: 97; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.33 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 14.6857; Friction: 0.106423; Pressure Drop: 0.115222; Velocity Pressure: 3.67217; Reynolds number: 62633.6
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1774
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 4 m; Start Offset: 4 m; End Offset: 4 m; Slope: 0
PSet_Revit_Dimensions - Size: 350x150; Width: 1.14829; Height: 0.492126; Length: 0.33 m
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569966
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569966
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.9016 m; Start Offset: 2.9016 m; End Offset: 3.71893 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0711457; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.817334 m
PSet_Revit_Identity Data - Mark: 1775
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 2.9016 m; Top Elevation: 3.71893 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0569366; Hydraulic Diameter: 0.984252; Section: 96; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.980801 m2
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569969
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569969
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.9016 m; Start Offset: 2.9016 m; End Offset: 3.625 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0629691; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 2.9016 m; Top Elevation: 3.625 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0503931; Hydraulic Diameter: 0.984252; Section: 93; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.86808 m2
PSet_Revit_Identity Data - Mark: 1776
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.7234 m
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569971
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569971
PSet_Revit_Dimensions - Size: 350x200; Width: 1.14829; Height: 0.656168; Length: 3.92 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.9 m; Top Elevation: 4.1 m; Equivalent Diameter: 0.939775; Size Lock: no; Loss Coefficient: 0.268206; Hydraulic Diameter: 0.835123; Section: 87; Insulation Thickness: 0; Lining Thickness: 0; Area: 4.312 m2
PSet_Revit_Mechanical - Airflow - Flow: 16.5979; Additional Flow: 0; Velocity: 22.0285; Friction: 0.172307; Pressure Drop: 2.21602; Velocity Pressure: 8.26239; Reynolds number: 113879
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 4 m; Start Offset: 4 m; End Offset: 4 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1777
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
