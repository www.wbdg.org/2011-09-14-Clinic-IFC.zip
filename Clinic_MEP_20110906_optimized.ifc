Properties of the parts of a building model (IFC2X3), part 295 of 295

# IfcFlowTerminal: Standard (958)
Name (M_Duplex Receptacle:Standard:Standard:...) | In | Mark | Panel | Circuit Number | Host | Elevation (m) | Schedule Level
869589 | 1C17 | 82 | N21C | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
960302 | 2D12 | 710 | N22B | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
902383 | 1E09 | 351 | N21E2 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
972105 | 2A01 | 816 | N22C | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
982423 | 2C19 | 919 | N22C1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
967336 | 2A08 | 764 | N22C | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
969530 | 2A04 | 790 | N22C | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
911154 | 1D31 | 424 | N21E1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
906928 | 1E12 | 394 | N21E2 | 28 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
977267 | 2C11 | 874 | N22C1 | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
970325 | 2A03 | 798 | N22C | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
954208 | 2D03 | 660 | N22B | 28 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
975214 | 2C02 | 844 | N22C1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
922941 | 1D12 | 496 | N21C1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
900345 | 1E18 | 336 | N21E2 | 19 | M_Lighting and Appliance Panelboard - 208V MLO : F41E | 0.5 | Level 1
871422 | 1D16 | 102 | N21C1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
879796 | 1A06 | 181 | N21B1 | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
911635 | 1D31 | 429 | N21E1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
904400 | 1E06 | 375 | N21E2 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
974049 | 2A12 | 833 | N22C | 24 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
982591 | 2C10 | 921 | N22C1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
893626 | 1AC1 | 277 | N21B1 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
932602 | 1D25 | 523 | N21E1 | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
870278 | 1D16 | 89 | N21C1 | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
960228 | 2D18 | 709 | N22B | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
948258 | 2B17 | 609 | N22B1 | 29 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
916503 | 1D22 | 462 | N21E1 | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
983750 | 2C12 | 926 | N22C1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
905203 | 1D38 | 381 | N21E1 | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
916580 | 1D22 | 464 | N21E1 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
863378 | 1C12 | 16 | N21C | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
983550 | 2C12 | 924 | N22C1 | 16 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
900244 | 1E18 | 332 | N21E2 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
881371 | 1A02 | 192 | N21B1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
960502 | 2D11 | 711 | N22B | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
872376 | 1D07 | 107 | N21C1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
930768 | 1DC1 | 518 | N21E1 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
982349 | 2C19 | 918 | N22C1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
985665 | 2C22 | 937 | N22C1 | 26 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
978116 | 2C14 | 885 | N22C1 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
961109 | 2D10 | 717 | N22B | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
976546 | 2C06 | 865 | N22C1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
981931 | 2C19 | 915 | N22C1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
894253 | 1B15 | 280 | N21B | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
913391 | 1D23 | 445 | N21E1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
984619 | 2C08 | 931 | N22C1 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
923928 | 1DC2 | 503 | N21C1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
913059 | 1D25 | 441 | N21E1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
978335 | 2C16 | 888 | N22C1 | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
954079 | 2D02 | 658 | N22B | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
961892 | 2D09 | 723 | N22B | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
912086 | 1D30 | 434 | N21E1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
877644 | 1A05 | 158 | N21B1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
870465 | 1D16 | 90 | N21C1 | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
976503 | 2C06 | 864 | N22C1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
971891 | 2A01 | 815 | N22C | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
905277 | 1E05 | 382 | N21E2 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
985250 | 2C22 | 934 | N22C1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
962257 | 2D07 | 730 | N22B | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
977104 | 2C09 | 873 | N22C1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
900568 | 1E16 | 338 | N21E2 | 16 | M_Lighting and Appliance Panelboard - 208V MLO : N21E1 | 0.5 | Level 1
913102 | 1D25 | 442 | N21E1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
981334 | 2CC1 | 911 | N22C1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
959941 | 2D13 | 708 | N22B | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
934477 | 1B17 | 529 | N21B | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
977764 | 2C14 | 882 | N22C1 | 23 | Linked Revit Model : Clinic_S.rvt | 0.5 | Level 2
912390 | 1DC1 | 437 | N21E1 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
965754 | 2D05 | 745 | N22C1 | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
886255 | 1B04 | 215 | N21B | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
966860 | 2A09 | 756 | N22C | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
928897 | 1D16 | 512 | N21C1 | 16 | Grid : F | 0.5 | Level 1
980326 | 2C17 | 906 | N22C1 | 8 | Linked Revit Model : Clinic_S.rvt | 0.5 | Level 2
958305 | 2D17 | 690 | N22B | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
872113 | 1D07 | 104 | N21C1 | 2 | Grid : F | 0.5 | Level 1
869970 | 1D16 | 86 | N21C1 | 17 | Grid : F | 0.5 | Level 1
934056 | 1A05 | 525 | N21B1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
892376 | 1A14 | 268 | N21B1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
880885 | 1A04 | 186 | N21B1 | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
913699 | 1D24 | 448 | N21E1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
870054 | 1D16 | 87 | N21C1 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
961003 | 2D11 | 715 | N22B | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
953995 | 2D02 | 657 | N22B | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
900935 | 1E16 | 342 | N21E2 | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
894656 | 1B15 | 282 | N21B | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
976048 | 2C04 | 858 | N22C1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
903125 | 1E08 | 362 | N21E2 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
964679 | 2D21 | 740 | N22B | 29 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
984429 | 2CC1 | 930 | N22C1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
900165 | 1E18 | 331 | N21E2 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
900268 | 1E18 | 333 | N21E2 | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
889364 | 1B10 | 245 | N21B | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
971607 | 2A01 | 812 | N22C | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
890353 | 1E01 | 252 | N21E2 | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
901283 | 1EC1 | 346 | N21E2 | 27 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
986060 | 2C03 | 941 | N22C1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
959800 | 2D16 | 705 | N22B | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
892484 | 1A15 | 270 | N21B1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
930580 | 1DC1 | 517 | N21E1 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
899929 | 1E16 | 326 | N21E2 | 22 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
890210 | 1E01 | 251 | N21E2 | 8 | Grid : 4 | 0.5 | Level 1
976776 | 2C09 | 868 | N22C1 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
958689 | 2D17 | 692 | N22B | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
977697 | 2C14 | 880 | N22C1 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
868524 | 1C10 | 66 | N21C | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
922817 | 1D15 | 495 | N21C1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
976733 | 2C09 | 867 | N22C1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
971661 | 2A01 | 813 | N22C | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
975836 | 2C04 | 854 | N22C1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
922710 | 1DC1 | 494 | N21C1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
977385 | 2CS3 | 876 | N22C1 | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
950844 | 2B18 | 631 | N22B1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
892836 | 1A15 | 272 | N21B1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
975922 | 2C06 | 856 | N22C1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
981238 | 2D05 | 910 | N22C1 | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
978159 | 2C14 | 886 | N22C1 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
971725 | 2A01 | 814 | N22C | 16 | M_Lighting Switches : Single Pole | 0.5 | Level 2
962214 | 2D07 | 729 | N22B | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
975608 | 2C04 | 850 | N22C1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
893077 | 1A01 | 275 | N21B1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
906447 | 1E08 | 390 | N21E2 | 30 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
900026 | 1E18 | 329 | N21E2 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
872432 | 1D07 | 108 | N21C1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
900128 | 1E16 | 330 | N21E2 | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
880693 | 1A06 | 184 | N21B1 | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
889712 | 1B14 | 247 | N21B | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
880544 | 1A06 | 182 | N21B1 | 18 | Grid : G | 0.5 | Level 1
928950 | 1D18 | 513 | N21C1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
906845 | 1E11 | 393 | N21E2 | 30 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
904228 | 1E05 | 374 | N21E2 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
984742 | 2C07 | 932 | N22C1 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
965919 | 2R02 | 747 | N22C1 | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
880950 | 1A04 | 187 | N21B1 | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
980932 | 2D05 | 909 | N22C1 | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
916534 | 1D22 | 463 | N21E1 | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
913145 | 1D25 | 443 | N21E1 | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
969456 | 2A04 | 789 | N22C | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
912995 | 1D25 | 440 | N21E1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
913238 | 1D25 | 444 | N21E1 | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
965367 | 2D05 | 744 | N22C1 | 24 | Grid : 6 | 0.5 | Level 2
969153 | 2A04 | 788 | N22C | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
965877 | 2D05 | 746 | N22C1 | 24 | Linked Revit Model : Clinic_S.rvt | 0.5 | Level 2
977061 | 2C09 | 872 | N22C1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
954153 | 2D03 | 659 | N22B | 28 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
900402 | 1E18 | 337 | N21E2 | 19 | M_Lighting and Appliance Panelboard - 208V MLO : F21E | 0.5 | Level 1
976091 | 2C06 | 859 | N22C1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
980434 | 2C17 | 908 | N22C1 | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
905620 | 1D38 | 383 | N21E1 | 24 | Orphaned | 0.5 | Level 1
872166 | 1D07 | 105 | N21C1 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
913475 | 1D23 | 446 | N21E1 | 15 | Grid : D.1 | 0.5 | Level 1
900578 | 1E16 | 339 | N21E2 | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
981867 | 2C19 | 914 | N22C1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
984796 | 2C22 | 933 | N22C1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
912033 | 1D30 | 433 | N21E1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
906002 | 1E06 | 385 | N21E2 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
958230 | 2D19 | 689 | N22B | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
934171 | 1A10 | 526 | N21B1 | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
959586 | 2D16 | 704 | N22B | 4 | Grid : 6.7 | 0.5 | Level 2
892440 | 1A14 | 269 | N21B1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
912129 | 1D27 | 435 | N21E1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
965324 | 2D05 | 743 | N22C1 | 24 | Grid : 6 | 0.5 | Level 2
906679 | 1E11 | 392 | N21E2 | 30 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
872221 | 1D07 | 106 | N21C1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
912347 | 1D27 | 436 | N21E1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
905813 | 1E06 | 384 | N21E2 | 5 | Grid : C | 0.5 | Level 1
981750 | 2C19 | 913 | N22C1 | 12 | M_Lighting and Appliance Panelboard - 208V MLO : N22C2 | 0.5 | Level 2

# IfcFlowTerminal: Standard (4)
Type - ElementType: Standard; PredefinedType: SANITARYFOUNTAIN
PSet_Revit_Other - TagNumber: R2201; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Domestic Cold Water,Sanitary; System Name: Domestic Cold Water 1,Sanitary 1
PSet_Revit_Plumbing - Flow Pressure: 16812.2
PSet_Revit_Constraints - Host: Linked Revit Model : Clinic_A.rvt
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - Width 1: 0.165 m; Thickness: 0.15 m; Half Fountain Width: 0.15 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; Type Mark: R2201; OmniClass Number: 23.65.70.14.11; OmniClass Title: Drinking Fountains/Coolers
PSet_Revit_Type_Constraints - Default Elevation: 0.915 m
PSet_Revit_Type_Dimensions - Fountain Width: 0.3 m; Fountain Length: 0.3 m; Sanitary Radius: 0.0524934; Sanitary Diameter: 0.104987; Cold Water Radius: 0.0164042; Cold Water Diameter: 0.0328084
PSet_Revit_Type_Mechanical - WFU: 0.5; HWFU: 0; CWFU: 0.25
Name (M_Drinking Fountain - Rectangular - Wall Mounted:Standard:Standard:...) | In | Mark | Elevation (m)
1086365 | 1AC2 | 169 | 0
1086140 | 1AC2 | 167 | 1 | PSet_Revit_Other - Schedule Level: Level 1
1085990 | 2AC1 | 166 | 0
1085411 | 2AC1 | 165 | 1 | PSet_Revit_Other - Schedule Level: Level 2

# IfcFlowTerminal: Three Way (4)
Type - ElementType: Three Way
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Electrical - Circuiting - Electrical Data: 120 V/1-0 VA
PSet_Revit_Electrical - Switch Voltage: 1291.67
PSet_Revit_Other - Schedule Level: Level 1; TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Elevation: 1.2 m; Offset: 0 m
PSet_Revit_Type_Identity Data - Label: 3; Manufacturer: Manufacturer; OmniClass Number: 23.80.50.11.14; OmniClass Title: Switches
PSet_Revit_Type_Electrical - Loads - Apparent Load: 0
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Electrical - Load Classification: Other
PSet_Revit_Type_Constraints - Default Elevation: 1.2 m
Name (M_Lighting Switches:Three Way:Three Way:...) | In | Host | Panel | Circuit Number
798953 | 1C18 | Linked Revit Model : Clinic_A.rvt | L41C | 4
798387 | 1C18 | Linked Revit Model : Clinic_A.rvt | L41C | 4
811180 | 1DC1 | Grid : D.9 | L41C | 6
803977 | 1C10 | Linked Revit Model : Clinic_A.rvt | N21C1 | 22
