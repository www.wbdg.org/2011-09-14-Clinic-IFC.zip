Properties of the parts of a building model (IFC2X3), part 33 of 295

# IfcFlowFitting: Standard (800)
Name | In | Level | Host | Offset (m) | Lining Width = Insulation Width | Lining Height = Insulation Height | Size | System Type | System Name | Mark | Takeoff Fixed Length | Takeoff Length Projection | Takeoff Length
M_Rectangular Takeoff:Standard:Standard:570112 | 2B8 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.656168 | 350x200-350x200 | Return Air | Mechanical Return Air 2 | 8607 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.656168; H0: 0.656168; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569684 | 2BC2 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 7596 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568430 | 1E25 | Level 2 | Level : Level 2 | -0.770492 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5225 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:567330 | 1E24 | Level 1 | Level : Level 1 | 3.79 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 1687 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Takeoff:Standard:Standard:568584 | 1E25 | Level 2 | Level : Level 2 | -0.78 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 1 | 5444 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:1117170 | 2BC1 | Level 2 | Level : Level 2 | 3.3595 |  |  | 150ø-150ø | Supply Air | Default Supply Air (cskender) | 848 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Tee:Standard:Standard:569120 | 2A02 | Roof - Main | Level : Roof - Main | -0.73 | 1.31234 | 1.14829 | 400x350-400x350-350x350 | Return Air | Mechanical Return Air 2 | 6091 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.656168; Height: 1.14829; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 0.656168; Length3: 0.738189; Length1a: 0.574147; Insulation Width3: 1.14829; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Round Takeoff:Standard:Standard:569210 | 2C13 | Roof - Main | Level : Roof - Main | -1.27049 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6266 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:570142 | 2B11 | Roof - Main | Level : Roof - Main | -0.68 | 1.31234 | 0.984252 | 400x300-400x300 | Return Air | Mechanical Return Air 2 | 8639 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.31234; W0: 1.31234; Length Multiplier: 0.25; H1: 0.984252; H0: 0.984252; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568646 | 1D22 | Level 1 | Level : Level 1 | 3.2095 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 5491 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Takeoff:Standard:Standard:568561 | 1B19 | Level 1 | Level : Level 1 | 3.2 | 0.984252 | 0.984252 | 300x300-300x300 | Return Air | Mechanical Return Air 1 | 5416 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.984252; W0: 0.984252; Length Multiplier: 0.25; H1: 0.984252; H0: 0.984252; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568713 | 1E05 | Level 1 | Level : Level 1 | 3.3 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 5532 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Takeoff:Standard:Standard:570547 | 1D35 | Level 2 | Level : Level 2 | -1.25094 | 0.82021 | 0.492126 | 250x150-250x150 | Supply Air | Default Supply Air (cskender) | 9250 | 0.328084 | 0.0200001 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568384 | 1EC1 | Level 2 | Level : Level 2 | -1.27 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 5132 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:568418 | 1B04 | Level 2 | Level : Level 2 | -0.88 |  |  | 350ø-350ø | Supply Air | Mechanical Supply Air 1 | 5194 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.574147; Lining Diameter: 1.14829; Insulation Diameter: 1.14829; Diameter: 1.14829
M_Rectangular Takeoff:Standard:Standard:570174 | 2BC1 | Roof - Main | Level : Roof - Main | -0.68 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 2 | 8690 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569802 | 2D18 | Roof - Main | Level : Roof - Main | -1.27052 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 7926 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Takeoff:Standard:Standard:568573 | 1E23 | Level 2 | Level : Level 2 | -0.755 | 0.656168 | 0.492126 | 200x150-200x150 | Return Air | Mechanical Return Air 1 | 5430 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.656168; W0: 0.656168; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:1121935 | 2D18 | Level 2 | Level : Level 2 | 3.6 |  |  | 350ø-350ø | Supply Air | Mechanical Supply Air 2 | 1232 | 0.328084 | 0.358502 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.574147; Lining Diameter: 1.14829; Insulation Diameter: 1.14829; Diameter: 1.14829
M_Rectangular Tee:Standard:Standard:567866 | 1E23 | Level 1 | Level : Level 1 | 3.40951 | 0.984252 | 0.82021 | 300x250-300x250-150x250 | Supply Air | Mechanical Supply Air 1 | 3378 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.328084; Height: 0.82021; Width3: 0.492126; Shoulder: 0.082021; Lining Width3: 0.492126; Length3a: 0.492126; Length3: 0.574147; Length1a: 0.246063; Insulation Width3: 0.492126
M_Rectangular Cross:Standard:Standard:567570 | 1B01 | Level 1 | Level : Level 1 | 3.79952 |  | 0.82021 | 250x250-250x250-150x250-75x250 | Supply Air | Mechanical Supply Air 1 | 2398 | PSet_Revit_Dimensions - Length1: 0.328084; Height: 0.82021; Width3: 0.492126; Shoulder: 0.082021; Lining Width3: 0.492126; Length3a: 0.410105; Length3: 0.492126; Length1a: 0.246063; Insulation Width3: 0.492126; Width4: 0.246063; Width1: 0.82021; Lining Width4: 0.246063; Lining Width1: 0.82021; Insulation Width4: 0.246063; Insulation Width1: 0.82021
M_Rectangular Tee:Standard:Standard:569146 | 2AC2 | Roof - Main | Level : Roof - Main | -0.73 | 2.46063 | 1.31234 | 750x400-750x400-350x400 | Return Air | Mechanical Return Air 2 | 6140 | PSet_Revit_Dimensions - Width: 2.46063; Length1: 0.656168; Height: 1.31234; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 1.23031; Length3: 1.31234; Length1a: 0.574147; Insulation Width3: 1.14829; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Round Takeoff:Standard:Standard:568638 | 1DC1 | Level 1 | Level : Level 1 | 3.20948 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5486 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:570107 | 2B25 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8603 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568404 | 1D38 | Level 2 | Level : Level 2 | -0.870481 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 5162 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Takeoff:Standard:Standard:570544 | 1D39 | Level 2 | Level : Level 2 | -1.25093 | 0.82021 | 0.492126 | 250x150-250x150 | Supply Air | Default Supply Air (cskender) | 9247 | 0.328084 | 0.0200001 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:1120951 | 1A16 | Level 1 | Level : Level 1 | 3.7095 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 1143 | 0.328084 | 0.0200013 | 0.328085 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568328 | 1DC3 | Level 2 | Level : Level 2 | -0.87 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 4977 | 0.328084 | 0.225982 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Takeoff:Standard:Standard:568470 | 1A04 | Level 1 | Level : Level 1 | 3.565 | 0.984252 | 0.984252 | 300x300-300x300 | Return Air | Mechanical Return Air 1 | 5278 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.984252; W0: 0.984252; Length Multiplier: 0.25; H1: 0.984252; H0: 0.984252; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:567469 | 1B04 | Level 1 | Level : Level 1 | 3.69 |  |  | 350ø-350ø | Supply Air | Mechanical Supply Air 1 | 2200 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.574147; Lining Diameter: 1.14829; Insulation Diameter: 1.14829; Diameter: 1.14829
M_Rectangular Takeoff:Standard:Standard:570541 | 1D40 | Level 2 | Level : Level 2 | -1.25093 | 0.82021 | 0.492126 | 250x150-250x150 | Supply Air | Default Supply Air (cskender) | 9244 | 0.328084 | 0.0200001 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:570533 | 1AC1 | Level 2 | Level : Level 2 | -1.116 | 0.82021 | 0.492126 | 250x150-250x150 | Supply Air | Default Supply Air (cskender) | 9236 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:569038 | 2A07 | Roof - Main | Level : Roof - Main | -0.68 | 1.31234 | 0.492126 | 400x150-400x150 | Return Air | Mechanical Return Air 2 | 5761 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.31234; W0: 1.31234; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Oval to Round Transition - Length:Standard:Standard:568189 | Level 1 | Level 2 | Level : Level 2 | -1.37 | 1.64042 | 0.984252 | 500/300-300ø | Supply Air | Mechanical Supply Air 1 | 4452 | PSet_Revit_Dimensions - Duct Width: 1.64042; Duct Height: 0.984252; Duct Length: 1.47638; OffsetHeight: 0.49212; OffsetWidth: 0.819979; Duct Radius: 0.492126; Lining Radius: 0.492126; Insulation Radius: 0.492126; Duct Diameter: 0.984252; PSet_Revit_Other - Length 1: 0.656168; Vertical Profile Offset: -0.00000550016; Horizontal Profile Offset: -0.000231007; Vertical Profile Offset 2: 0.246057; Half Height: 0.492126; Vertical Profile Offset 1: 0.246063; Offset Width 1: 9.99977; Offset Height 1: 10; Half Width: 0.82021
M_Round Takeoff:Standard:Standard:568708 | 1E28 | Level 1 | Level : Level 1 | 3.5096 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 5529 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Oval Elbow - Gored:Standard:Standard:1115314 | 2CC3 | Level 2 | Level : Level 2 | 3.6 | 4.59318 | 1.31234 | 1400/400-1400/400 | Supply Air | Mechanical Supply Air 2 | 749 | PSet_Revit_Dimensions - Angle: 90 deg; Duct Width: 4.59318; Duct Height: 1.31234; Max Segmentation Angle: 22.5 deg; Gores: 5; Center Radius: 6.88976; PSet_Revit_Mechanical - ASHRAE Table: CF3-1; PSet_Revit_Other - Length 3: 7.05381; Length 2: 6.88976; Length 1: 6.88976; End Length: 0.164042; Length 5: 0.164042; Length 4: 1.00443e-17
M_Round Takeoff:Standard:Standard:568201 | 1DC1 | Level 2 | Level : Level 2 | -1.36053 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 4497 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:569033 | 2A08 | Roof - Main | Level : Roof - Main | -0.68 | 1.31234 | 0.492126 | 400x150-400x150 | Return Air | Mechanical Return Air 2 | 5754 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.31234; W0: 1.31234; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:570434 | 2A02 | Level 2 | Level : Level 2 | 3.6095 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 8958 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:569133 | 2A14 | Roof - Main | Level : Roof - Main | -0.73 | 1.31234 | 1.31234 | 400x400-400x400-300x400 | Return Air | Mechanical Return Air 2 | 6117 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.574147; Height: 1.31234; Width3: 0.984252; Shoulder: 0.082021; Lining Width3: 0.984252; Length3a: 0.656168; Length3: 0.738189; Length1a: 0.492126; Insulation Width3: 0.984252; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Rectangular Takeoff:Standard:Standard:570095 | 2B24 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8593 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Oval Transition - Length:Standard:Standard:569067 | 2AC3 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 1000/400-900/400 | Supply Air | Mechanical Supply Air 2 | 5849 | PSet_Revit_Other - Length 1: 0.328084; Width Offset: 10; Width 1: 0.328084; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Height Offset: 10; Height 1: 0; Half Width 2: 1.47638; Half Width 1: 1.64042; Half Height 2: 0.656168; Half Height 1: 0.656168; Height 2: 0; Width 2: 0; PSet_Revit_Dimensions - Duct Width 2: 2.95276; Duct Width 1: 3.28084; Lining Duct Width 2: 2.95276; Lining Duct Width 1: 3.28084; Lining Duct Height 2: 1.31234; Lining Duct Height 1: 1.31234; Duct Length: 0.984252; Insulation Duct Width 2: 2.95276; Insulation Duct Width 1: 3.28084; Insulation Duct Height 2: 1.31234; Insulation Duct Height 1: 1.31234; Duct Height 2: 1.31234; Duct Height 1: 1.31234; OffsetHeight: 0.656168; OffsetWidth: 1.64042
M_Rectangular Takeoff:Standard:Standard:570132 | 2B10 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8629 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568346 | 1D04 | Level 2 | Level : Level 2 | -0.87 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 1 | 4999 | 0.328084 | 0.472126 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Rectangular Takeoff:Standard:Standard:1138886 | 1D07 | Level 1 | Level : Level 1 | 3.3 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 1 | 1556 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568318 | 1D02 | Level 2 | Level : Level 2 | -0.860493 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 4939 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Tee:Standard:Standard:569137 | 2A11 | Roof - Main | Level : Roof - Main | -0.73 | 1.31234 | 1.80446 | 400x550-400x550-300x550 | Return Air | Mechanical Return Air 2 | 6125 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.574147; Height: 1.80446; Width3: 0.984252; Shoulder: 0.082021; Lining Width3: 0.984252; Length3a: 0.656168; Length3: 0.738189; Length1a: 0.492126; Insulation Width3: 0.984252; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Round Takeoff:Standard:Standard:567670 | 1D25 | Level 1 | Level : Level 1 | 3.29048 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 2755 | 0.328084 | 0.0814416 | 0.328825 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:568364 | 1C14 | Level 2 | Level : Level 2 | -1.26049 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5070 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:569012 | 2C06 | Roof - Main | Level : Roof - Main | -0.68 | 1.47638 | 0.492126 | 450x150-450x150 | Return Air | Mechanical Return Air 2 | 5724 | 0.369094 | 0.02 | 0.369094 | PSet_Revit_Dimensions - W1: 1.47638; W0: 1.47638; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569301 | 2C02 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 2 | 6574 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Oval Tap - Straight:Standard:Standard:567692 | 1D32 | Level 1 | Level : Level 1 | 3.69 |  |  | 700/500-700/500 | Supply Air | Mechanical Supply Air 1 | 2843 | 0.574147 | 0.84021 | 0.574147 | PSet_Revit_Dimensions - Length Multiplier: 0.25; Duct Width 2: 2.29659; Duct Width 1: 2.29659; Duct Height 2: 1.64042; Duct Height 1: 1.64042; Lining Width 2: 2.29659; Lining Height 2: 1.64042; Insulation Width 2: 2.29659; Insulation Height 2: 1.64042; Lining Width 1: 2.29659; Lining Height 1: 1.64042; Insulation Width 1: 2.29659; Insulation Height 1: 1.64042
M_Rectangular Takeoff:Standard:Standard:570157 | 2B4 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8676 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:567228 | 1D25 | Level 1 | Level : Level 1 | 3.8 | 1.47638 | 0.984252 | 450x300-450x300 | Return Air | Mechanical Return Air 1 | 1459 | 0.369094 | 0.02 | 0.369094 | PSet_Revit_Dimensions - W1: 1.47638; W0: 1.47638; Length Multiplier: 0.25; H1: 0.984252; H0: 0.984252; ConnectorOffset: 0
M_Oval to Round Transition - Length:Standard:Standard:1115601 | 2CC5 | Level 2 | Level : Level 2 | 3.4 | 1.9685 | 1.31234 | 600/400-350ø | Supply Air | Mechanical Supply Air 2 | 781 | PSet_Revit_Dimensions - Duct Width: 1.9685; Duct Height: 1.31234; Duct Length: 0.984252; OffsetHeight: 0.656168; OffsetWidth: 0.984252; Duct Radius: 0.574147; Lining Radius: 0.574147; Insulation Radius: 0.574147; Duct Diameter: 1.14829; PSet_Revit_Other - Length 1: 0.82021; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Vertical Profile Offset 2: 0.287073; Half Height: 0.656168; Vertical Profile Offset 1: 0.328084; Offset Width 1: 10; Offset Height 1: 10; Half Width: 0.984252
M_Round Takeoff:Standard:Standard:567328 | 1E24 | Level 1 | Level : Level 1 | 3.79 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 1677 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Oval Transition - Length:Standard:Standard:569065 | 2AC3 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 1150/400-1000/400 | Supply Air | Mechanical Supply Air 2 | 5839 | PSet_Revit_Other - Length 1: 0.492126; Width Offset: 10; Width 1: 0.492126; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Height Offset: 10; Height 1: 0; Half Width 2: 1.64042; Half Width 1: 1.88648; Half Height 2: 0.656168; Half Height 1: 0.656168; Height 2: 0; Width 2: 0; PSet_Revit_Dimensions - Duct Width 2: 3.28084; Duct Width 1: 3.77297; Lining Duct Width 2: 3.28084; Lining Duct Width 1: 3.77297; Lining Duct Height 2: 1.31234; Lining Duct Height 1: 1.31234; Duct Length: 0.984252; Insulation Duct Width 2: 3.28084; Insulation Duct Width 1: 3.77297; Insulation Duct Height 2: 1.31234; Insulation Duct Height 1: 1.31234; Duct Height 2: 1.31234; Duct Height 1: 1.31234; OffsetHeight: 0.656168; OffsetWidth: 1.88648
M_Round Takeoff:Standard:Standard:569306 | 2C01 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 6595 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:568415 | 1B13 | Level 2 | Level : Level 2 | -0.770484 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5184 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:567086 | 1E06 | Level 1 | Level : Level 1 | 3.3 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 1 | 1189 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569862 | 2BC5 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 8092 | 0.328084 | 0.240093 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Takeoff:Standard:Standard:569069 | 2A07 | Roof - Main | Level : Roof - Main | -0.68 | 0.82021 | 0.656168 | 250x200-250x200 | Return Air | Mechanical Return Air 2 | 5876 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.656168; H0: 0.656168; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568338 | 1D06 | Level 2 | Level : Level 2 | -0.860482 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 4989 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Takeoff:Standard:Standard:570125 | 2B8 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8623 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569863 | 2BC6 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 8096 | 0.328084 | 0.192328 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:568657 | 1D23 | Level 1 | Level : Level 1 | 3.3 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 5498 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Takeoff:Standard:Standard:570100 | 2B24 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8597 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:568119 | 1D16 | Level 1 | Level : Level 1 | 3.64 | 1.31234 | 0.492126 | 400x150-400x150 | Return Air | Mechanical Return Air 1 | 4267 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.31234; W0: 1.31234; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:567332 | 1E24 | Level 1 | Level : Level 1 | 3.79 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 1695 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Oval Transition - Length:Standard:Standard:567694 | 1D32 | Level 1 | Level : Level 1 | 3.69 |  |  | 700/500-600/500 | Supply Air | Mechanical Supply Air 1 | 2848 | PSet_Revit_Other - Length 1: 0.328084; Width Offset: 10; Width 1: 0.328084; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Height Offset: 10; Height 1: 0; Half Width 2: 0.984252; Half Width 1: 1.14829; Half Height 2: 0.82021; Half Height 1: 0.82021; Height 2: 0; Width 2: 0; PSet_Revit_Dimensions - Duct Width 2: 1.9685; Duct Width 1: 2.29659; Lining Duct Width 2: 1.9685; Lining Duct Width 1: 2.29659; Lining Duct Height 2: 1.64042; Lining Duct Height 1: 1.64042; Duct Length: 0.984252; Insulation Duct Width 2: 1.9685; Insulation Duct Width 1: 2.29659; Insulation Duct Height 2: 1.64042; Insulation Duct Height 1: 1.64042; Duct Height 2: 1.64042; Duct Height 1: 1.64042; OffsetHeight: 0.82021; OffsetWidth: 1.14829
M_Round Takeoff:Standard:Standard:568199 | 1DC1 | Level 2 | Level : Level 2 | -1.36053 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 4484 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Takeoff:Standard:Standard:569018 | 2C04 | Roof - Main | Level : Roof - Main | -0.68 | 1.47638 | 0.492126 | 450x150-450x150 | Return Air | Mechanical Return Air 2 | 5731 | 0.369094 | 0.02 | 0.369094 | PSet_Revit_Dimensions - W1: 1.47638; W0: 1.47638; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:567628 | 1D32 | Level 1 | Level : Level 1 | 3.2905 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 2642 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Takeoff:Standard:Standard:569043 | 2A06 | Roof - Main | Level : Roof - Main | -0.68 | 1.31234 | 0.492126 | 400x150-400x150 | Return Air | Mechanical Return Air 2 | 5768 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.31234; W0: 1.31234; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569682 | 2BC2 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 7584 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569208 | 2C13 | Roof - Main | Level : Roof - Main | -1.27049 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 6256 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:1119485 | 1C03 | Level 1 | Level : Level 1 | 3.7 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 1 | 993 | 0.328084 | 0.184042 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Rectangular Takeoff:Standard:Standard:570443 | 2D05 | Roof - Main | Level : Roof - Main | -3.78 | 2.95276 | 2.95276 | 900x900-900x900 | Supply Air | Mechanical Supply Air 1 | 8987 | 0.738189 | 0.02 | 0.738189 | PSet_Revit_Dimensions - W1: 2.95276; W0: 2.95276; Length Multiplier: 0.25; H1: 2.95276; H0: 2.95276; ConnectorOffset: 0
M_Rectangular Tee:Standard:Standard:568489 | 1A01 | Level 2 | Level : Level 2 | -1.325 | 0.492126 | 1.14829 | 300x350-150x350-150x350 | Return Air | Mechanical Return Air 1 | 5312 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.574147; Height: 1.14829; Width3: 0.984252; Shoulder: 0.082021; Lining Width3: 0.984252; Length3a: 0.246063; Length3: 0.328084; Length1a: 0.492126; Insulation Width3: 0.984252
M_Round Takeoff:Standard:Standard:567640 | 1D25 | Level 1 | Level : Level 1 | 3.3994 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 2662 | 0.328084 | 0.02 | 0.452682 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:570115 | 2B8 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8611 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:570137 | 2B10 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8633 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569204 | 2CC5 | Roof - Main | Level : Roof - Main | -1.28 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6243 | 0.328084 | 0.10791 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:570535 | 1AC1 | Level 2 | Level : Level 2 | -1.116 | 0.82021 | 0.492126 | 250x150-250x150 | Supply Air | Default Supply Air (cskender) | 9238 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568302 | 1DC3 | Level 2 | Level : Level 2 | -0.87 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 4867 | 0.328084 | 0.163947 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Takeoff:Standard:Standard:570090 | 2B23 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8589 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568372 | 1D34 | Level 2 | Level : Level 2 | -0.779998 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5103 | 0.328084 | 0.280979 | 0.408862 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Oval Transition - Length:Standard:Standard:569063 | 2CC2 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 1400/400-1150/400 | Supply Air | Mechanical Supply Air 2 | 5828 | PSet_Revit_Other - Length 1: 0.82021; Width Offset: 10; Width 1: 0.82021; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Height Offset: 10; Height 1: 0; Half Width 2: 1.88648; Half Width 1: 2.29659; Half Height 2: 0.656168; Half Height 1: 0.656168; Height 2: 0; Width 2: 0; PSet_Revit_Dimensions - Duct Width 2: 3.77297; Duct Width 1: 4.59318; Lining Duct Width 2: 3.77297; Lining Duct Width 1: 4.59318; Lining Duct Height 2: 1.31234; Lining Duct Height 1: 1.31234; Duct Length: 0.984252; Insulation Duct Width 2: 3.77297; Insulation Duct Width 1: 4.59318; Insulation Duct Height 2: 1.31234; Insulation Duct Height 1: 1.31234; Duct Height 2: 1.31234; Duct Height 1: 1.31234; OffsetHeight: 0.656168; OffsetWidth: 2.29659
M_Rectangular Takeoff:Standard:Standard:568465 | 1A06 | Level 2 | Level : Level 2 | -0.93 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 1 | 5267 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:567680 | 1EC3 | Level 1 | Level : Level 1 | 3.29998 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 2816 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:567648 | 1D25 | Level 1 | Level : Level 1 | 3.29048 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 2709 | 0.328084 | 0.107949 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:568316 | 1DC2 | Level 2 | Level : Level 2 | -0.860493 | 0.492126 | 0.82021 | 150x250-150x250 | Supply Air | Mechanical Supply Air 1 | 4920 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.492126; W0: 0.492126; Length Multiplier: 0.25; H1: 0.82021; H0: 0.82021; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:570167 | 2D02 | Roof - Main | Level : Roof - Main | -0.68 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 2 | 8684 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568406 | 1D38 | Level 2 | Level : Level 2 | -0.870499 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 5168 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Tee:Standard:Standard:569141 | 2AC1 | Roof - Main | Level : Roof - Main | -0.73 | 1.31234 | 1.80446 | 400x550-400x550-300x550 | Return Air | Mechanical Return Air 2 | 6130 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.574147; Height: 1.80446; Width3: 0.984252; Shoulder: 0.082021; Lining Width3: 0.984252; Length3a: 0.656168; Length3: 0.738189; Length1a: 0.492126; Insulation Width3: 0.984252; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Round Takeoff:Standard:Standard:568411 | 1B13 | Level 2 | Level : Level 2 | -0.770484 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5176 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:567665 | 1D25 | Level 1 | Level : Level 1 | 3.29048 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 2749 | 0.328084 | 0.127083 | 0.328825 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568303 | 1DC3 | Level 2 | Level : Level 2 | -0.87 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 4871 | 0.328084 | 0.0754006 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:567614 | 1D25 | Level 1 | Level : Level 1 | 3.28098 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 2604 | 0.328084 | 0.143763 | 0.328744 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Takeoff:Standard:Standard:569023 | 2C02 | Roof - Main | Level : Roof - Main | -0.68 | 1.31234 | 0.492126 | 400x150-400x150 | Return Air | Mechanical Return Air 2 | 5740 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.31234; W0: 1.31234; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:570162 | 2B7 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8680 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:995637 | 2D18 | Level 2 | Level : Level 2 | 3.4 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 101 | 0.328084 | 0.102021 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Takeoff:Standard:Standard:568308 | 1DC2 | Level 2 | Level : Level 2 | -0.860492 | 0.492126 | 0.82021 | 150x250-150x250 | Supply Air | Mechanical Supply Air 1 | 4888 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.492126; W0: 0.492126; Length Multiplier: 0.25; H1: 0.82021; H0: 0.82021; ConnectorOffset: 0

# IfcFlowFitting: Tee - Generic (921)
Type - ElementType: Tee - Generic
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Insulation Thickness: 0; Loss Method: 5; K Coefficient Table: Tee
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.60.30.11.14; OmniClass Title: Pipework Fittings
PSet_Revit_Type_Mechanical - Loss Method: 1; K Coefficient Table: Tee
PSet_Revit_Type_Other - Lookup Table Name: M_Pipe Fitting - Generic.csv; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Tee - Generic:Tee - Generic:Tee - Generic:...) | In | Center to End Label | Fitting Outside Radius = Insulation Radius | Angle 1 (deg) | Tick Size | Nominal Radius | Nominal Diameter | Fitting Outside Diameter | Center to End | Angle (deg) | Size | System Type | System Name | Mark | Level | Host | Offset (m)
646724 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3117 | Level 1 | Level : Level 1 | -0.501123
646384 | TOF Footing | 0.130208 | 0.0885417 | 89.5925 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 89.5925 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 3062 | Level 1 | Level : Level 1 | -0.501164
645854 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Sanitary | Sanitary 1 | 2977 | Level 1 | Level : Level 1 | -0.3
646357 | TOF Footing | 0.305947 | 0.0885417 | 32.2811 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 32.2811 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 3056 | Level 1 | Level : Level 1 | -0.501164
646859 | Level 1 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 3132 | Level 1 | Level : Level 1 | 0
645866 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2980 | Level 1 | Level : Level 1 | -0.5
679589 | Level 1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5059 | Level 1 | Level : Level 1 | 0.371263
646758 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 3124 | Level 1 | Level : Level 1 | -0.5
678524 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 4954 | Level 1 | Level : Level 1 | -0.4
646269 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 3047 | Level 1 | Level : Level 1 | -0.501123
659508 | 2C17 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 3817 | Level 2 | Level : Level 2 | 3
662596 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4227 | Level 2 | Level : Level 2 | 0.2
679184 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5000 | Level 1 | Level : Level 1 | -0.4
1029501 | 2AC2 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 11753 | Level 2 | Level : Level 2 | 2.985
666517 | 1DC3 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4640 | Level 2 | Level : Level 2 | -1.56
691274 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6411 | Level 1 | Level : Level 1 | -0.4
662498 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4213 | Level 2 | Level : Level 2 | 2.9
1001209 | 1EC4 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10135 | Level 1 | Level : Level 1 | 2.985
1029703 | 2BC2 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 11780 | Level 2 | Level : Level 2 | 2.98519
1029577 | 2CC2 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11763 | Level 2 | Level : Level 2 | 2.985
665083 | Level 2 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4502 | Level 2 | Level : Level 2 | 0.232932
663133 | Level 2 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 4300 | Level 2 | Level : Level 2 | 0.2
645705 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2941 | Level 1 | Level : Level 1 | -0.501123
691091 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6376 | Level 1 | Level : Level 1 | -0.4
667077 | 1D03 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4738 | Level 2 | Level : Level 2 | -1.56
646650 | TOF Footing | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 3114 | Level 1 | Level : Level 1 | -0.3
690850 | TOF Footing | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6325 | Level 1 | Level : Level 1 | -0.4
666196 | TOF Footing | 0.41494 | 0.171875 | 45.0003 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45.0003 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4604 | Level 1 | Level : Level 1 | -0.501123
1043056 | 2BC2 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 11903 | Level 2 | Level : Level 2 | 2.98519
644845 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2860 | Level 1 | Level : Level 1 | -0.501123
681050 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5184 | Level 1 | Level : Level 1 | -0.4
655494 | 1B05 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 3438 | Level 2 | Level : Level 2 | -0.411
648098 | 1C09 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 3250 | Level 1 | Level : Level 1 | 0
667465 | Level 2 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 4781 | Level 2 | Level : Level 2 | 2.9
662519 | Level 1 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4215 | Level 2 | Level : Level 2 | -1.6882
654592 | 1BC2 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 3363 | Level 2 | Level : Level 2 | -0.411
655501 | Level 1 | 0.213758 | 0.0885417 | 45 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 45 | 50 mmø-50 mmø-50 mmø | Sanitary | Default Sanitary (cskender) | 3444 | Level 2 | Level : Level 2 | -0.2
691937 | 1B04 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6450 | Level 2 | Level : Level 2 | -1.5
666844 | 1DC3 | 0.319312 | 0.130208 | 44.3691 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 44.3691 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 4710 | Level 2 | Level : Level 2 | -1.56
679813 | TOF Footing | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5072 | Level 1 | Level : Level 1 | -0.4
667003 | 1DC3 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 4723 | Level 2 | Level : Level 2 | -1.56
664525 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4443 | Level 2 | Level : Level 2 | 0.5
627924 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.164042 | 0.328084 | 0.09375 | 0.0885417 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 636 | Level 1 | Level : Level 1 | -0.5
660941 | 1C13 | 0.314351 | 0.130208 | 45 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 45 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 3990 | Level 2 | Level : Level 2 | -1.6882
667063 | 2C07 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 4733 | Level 2 | Level : Level 2 | 2.9
1047522 | 2C13 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11928 | Level 2 | Level : Level 2 | 2.985
681522 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5254 | Level 1 | Level : Level 1 | -0.4
645953 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2993 | Level 1 | Level : Level 1 | -0.5
646046 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3001 | Level 1 | Level : Level 1 | -0.5
1027407 | 1BC2 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11389 | Level 1 | Level : Level 1 | 2.985
681288 | Level 1 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5211 | Level 1 | Level : Level 1 | 0.371263
690430 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6283 | Level 1 | Level : Level 1 | -0.4
654059 | Level 2 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 3320 | Level 2 | Level : Level 2 | 0.232932
1027692 | 1A01 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11477 | Level 1 | Level : Level 1 | 2.985
1029520 | 2AC2 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 11757 | Level 2 | Level : Level 2 | 2.985
1027726 | 1A02 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11489 | Level 1 | Level : Level 1 | 2.985
681367 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5222 | Level 1 | Level : Level 1 | -0.4
659242 | 1D16 | 0.314351 | 0.130208 | 45 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 135 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 3794 | Level 2 | Level : Level 2 | -1.6882
1048140 | 2C15 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12041 | Level 2 | Level : Level 2 | 2.985
659884 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 3854 | Level 2 | Level : Level 2 | 0.2
646276 | TOF Footing | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 3053 | Level 1 | Level : Level 1 | -0.3
655913 | 1E12 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3485 | Level 2 | Level : Level 2 | -1.4
654324 | 1B11 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 3348 | Level 2 | Level : Level 2 | -0.411
708891 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8441 | Level 1 | Level : Level 1 | -0.3
678948 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 4976 | Level 1 | Level : Level 1 | -0.4
1029361 | 2A11 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11744 | Level 2 | Level : Level 2 | 2.985
681669 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5265 | Level 1 | Level : Level 1 | -0.4
718539 | 1AC3 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9416 | Level 2 | Level : Level 2 | -1.4
690941 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6338 | Level 1 | Level : Level 1 | -0.4
666118 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4589 | Level 2 | Level : Level 2 | 0.2
691331 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6419 | Level 1 | Level : Level 1 | -0.4
646067 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Sanitary | Sanitary 1 | 3006 | Level 1 | Level : Level 1 | -0.3
645541 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2916 | Level 1 | Level : Level 1 | -0.501123
687912 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5978 | Level 1 | Level : Level 1 | -0.4
1050699 | 2DC1 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12685 | Level 2 | Level : Level 2 | 2.98499
645813 | TOF Footing | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 2958 | Level 1 | Level : Level 1 | -0.5
646095 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3007 | Level 1 | Level : Level 1 | -0.5
660103 | 1DC4 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3885 | Level 2 | Level : Level 2 | -1.6882
659520 | 2C17 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 3818 | Level 2 | Level : Level 2 | 3
653952 | 1B04 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 3304 | Level 2 | Level : Level 2 | -0.411
1001284 | 1B04 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10139 | Level 1 | Level : Level 1 | 2.985
1048354 | 2CC1 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12089 | Level 2 | Level : Level 2 | 2.985
690165 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6256 | Level 1 | Level : Level 1 | -0.4
645923 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Sanitary | Sanitary 1 | 2990 | Level 1 | Level : Level 1 | -0.3
1051959 | 2AC2 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13009 | Level 2 | Level : Level 2 | 2.985
646199 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 3037 | Level 1 | Level : Level 1 | -0.501123
1050616 | 2D18 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12669 | Level 2 | Level : Level 2 | 2.985
661636 | 1CC1 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 4085 | Level 2 | Level : Level 2 | -1.6882
726387 | 1AC5 | 0.412968 | 0.130208 | 35 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 145 | 80 mmø-80 mmø-80 mmø | Sanitary | Storm | 9926 | Level 2 | Level : Level 2 | -0.444
1047507 | 2C14 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11920 | Level 2 | Level : Level 2 | 2.985
666734 | 2C07 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 4683 | Level 2 | Level : Level 2 | 2.9
646406 | TOF Footing | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 3070 | Level 1 | Level : Level 1 | -0.3
1028614 | 1A04 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11674 | Level 1 | Level : Level 1 | 2.985
664488 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4438 | Level 2 | Level : Level 2 | 0.2
1027047 | 1B19 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11281 | Level 1 | Level : Level 1 | 2.985
664332 | 1DC3 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4407 | Level 2 | Level : Level 2 | -1.6882
697761 | 1D10 | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7094 | Level 2 | Level : Level 2 | -1.5
1013283 | 1DC4 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10760 | Level 1 | Level : Level 1 | 2.985
655606 | 1B07 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Default Sanitary (cskender) | 3468 | Level 2 | Level : Level 2 | -0.2
705290 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7980 | Level 1 | Level : Level 1 | -0.4
