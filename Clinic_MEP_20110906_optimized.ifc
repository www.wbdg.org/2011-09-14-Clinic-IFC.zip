Properties of the parts of a building model (IFC2X3), part 27 of 295

# IfcFlowFitting: Rectangular Elbow - Mitered (53)
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Dimensions - Shoulder: 0.082021
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
Name (M_Rectangular Elbow - Mitered:Rectangular Elbow - Mitered:Rectangular Elbow - Mitered:...) | In | Level | Host | Offset (m) | System Type | System Name | ASHRAE Table | Mark | Width = Lining Width = Insulation Width | Lining Height = Insulation Height = Height | Length1 | Angle (deg) | Size
570629 | 1BC2 | Level 2 | Level : Level 2 | -1.116 | Supply Air | Default Supply Air (cskender) | CR3-17 | 286 | 0.82021 | 1.14829 | 0.251892 | 45 | 250x350-250x350
570626 | 1BC2 | Level 1 | Level : Level 1 | 3.69 | Supply Air | Default Supply Air (cskender) | CR3-17 | 276 | 0.82021 | 1.14829 | 0.251892 | 45 | 250x350-250x350
1114443 | 2D05 | Level 2 | Level : Level 2 | 3.2 | Supply Air | Mechanical Supply Air 1 |  | 693 | 2.29659 | 0.984252 | 0.172394 | 9 | 700x300-700x300
570682 | 1AC5 | Level 2 | Level : Level 2 | -1.116 | Supply Air | Default Supply Air (cskender) | CR3-17 | 469 | 0.656168 | 1.31234 | 0.217918 | 45 | 200x400-200x400
570660 | 1D02 | Level 2 | Level : Level 2 | -1.025 | Supply Air | Default Supply Air (cskender) | CR3-17 | 383 | 0.82021 | 1.31234 | 0.251892 | 45 | 250x400-250x400
1121353 | 1B10 | Level 1 | Level : Level 1 | 3.5 | Supply Air | Mechanical Supply Air 1 | CR3-17 | 1168 | 0.984252 | 0.984252 | 0.213886 | 30 | 300x300-300x300
1116594 | 2AC1 | Level 2 | Level : Level 2 | 2.8 | Supply Air | Default Supply Air (cskender) | SR3-1 | 816 | 0.82021 | 0.82021 | 0.492126 | 90 | 250x250-250x250
1119213 | 1C01 | Level 1 | Level : Level 1 | 3.3 | Supply Air | Mechanical Supply Air 1 | SR3-1 | 918 | 0.82021 | 0.656168 | 0.492126 | 90 | 250x200-250x200
1116403 | 2C19 | Level 2 | Level : Level 2 | 3.4095 | Supply Air | Default Supply Air (cskender) | SR3-1 | 810 | 0.984252 | 0.82021 | 0.574147 | 90 | 300x250-300x250
570684 | 1AC5 | Level 2 | Level : Level 2 | -1.116 | Supply Air | Default Supply Air (cskender) | SR3-1 | 473 | 1.31234 | 0.656168 | 0.738189 | 90 | 400x200-400x200
1116396 | 2C19 | Level 2 | Level : Level 2 | 2.5 | Supply Air | Default Supply Air (cskender) | SR3-1 | 805 | 0.984252 | 0.656168 | 0.574147 | 90 | 300x200-300x200
570689 | 1A16 | Level 2 | Level : Level 2 | -0.93 | Return Air | Mechanical Return Air 1 |  | 492 | 0.82021 | 1.80446 | 0.251892 | 45 | 250x550-250x550
1121359 | 1B10 | Level 1 | Level : Level 1 | 3.2 | Supply Air | Mechanical Supply Air 1 | CR3-17 | 1174 | 0.984252 | 0.984252 | 0.213886 | 30 | 300x300-300x300
1090141 | 1E16 | Level 1 | Level : Level 1 | 3.40948 | Supply Air | Default Supply Air (cskender) | SR3-1 | 225 | 0.984252 | 0.82021 | 0.574147 | 90 | 300x250-300x250
570696 | 1A16 | Level 2 | Level : Level 2 | -1.09 | Supply Air | Default Supply Air (cskender) | CR3-17 | 512 | 0.82021 | 1.47638 | 0.251892 | 45 | 250x450-250x450
570681 | 1AC5 | Level 2 | Level : Level 2 | -0.860476 | Supply Air | Default Supply Air (cskender) | CR3-17 | 466 | 0.656168 | 1.31234 | 0.217917 | 44.9998 | 200x400-200x400
570588 | 1A16 | Level 2 | Level : Level 2 | -0.860489 | Supply Air | Mechanical Supply Air 1 | CR3-1 | 141 | 0.82021 | 0.984252 | 0.4921 | 89.9964 | 250x300-250x300
570659 | 1D02 | Level 2 | Level : Level 2 | -0.840924 | Supply Air | Default Supply Air (cskender) | CR3-17 | 381 | 0.82021 | 1.31234 | 0.251892 | 45 | 250x400-250x400
1090142 | 1E16 | Level 1 | Level : Level 1 | 3.4095 | Supply Air | Default Supply Air (cskender) | CR3-1 | 226 | 0.82021 | 0.984252 | 0.492132 | 90.0009 | 250x300-250x300
1094520 | 2D05 | Level 2 | Level : Level 2 | 3.4 | Return Air | Mechanical Return Air 1 |  | 347 | 1.14829 | 2.29659 | 0.656168 | 90 | 350x700-350x700
570609 | 1B13 | Level 1 | Level : Level 1 | 3.454 | Supply Air | Default Supply Air (cskender) | CR3-17 | 249 | 1.14829 | 0.82021 | 0.175957 | 18.5836 | 350x250-350x250
1138758 | 1B10 | Level 1 | Level : Level 1 | 3.3 | Return Air | Mechanical Return Air 1 | CR3-1 | 1524 | 0.656168 | 0.656168 | 0.410105 | 90 | 200x200-200x200
1090758 | 1E14 | Level 1 | Level : Level 1 | 3.815 | Return Air | Mechanical Return Air 1 | CR3-1 | 241 | 0.492126 | 1.14829 | 0.328084 | 90 | 150x350-150x350
1116601 | 2AC1 | Level 2 | Level : Level 2 | 3.6095 | Supply Air | Default Supply Air (cskender) | SR3-1 | 826 | 0.82021 | 0.82021 | 0.492126 | 90 | 250x250-250x250
1116400 | 2C19 | Level 2 | Level : Level 2 | 3.4095 | Supply Air | Default Supply Air (cskender) | SR3-1 | 807 | 0.82021 | 0.984252 | 0.492126 | 90 | 250x300-250x300
1090133 | 1E16 | Level 1 | Level : Level 1 | 2.5 | Supply Air | Default Supply Air (cskender) | SR3-1 | 217 | 0.82021 | 0.984252 | 0.492126 | 90 | 250x300-250x300
1090516 | 1B23 | Level 1 | Level : Level 1 | 3.3 | Return Air | Mechanical Return Air 1 | CR3-1 | 232 | 0.328084 | 0.656168 | 0.246063 | 90 | 100x200-100x200
570693 | 1A16 | Level 2 | Level : Level 2 | -0.860481 | Supply Air | Default Supply Air (cskender) | CR3-17 | 500 | 0.82021 | 1.47638 | 0.25189 | 44.9994 | 250x450-250x450
1090839 | 1E19 | Level 1 | Level : Level 1 | 3.815 | Return Air | Mechanical Return Air 1 | CR3-1 | 245 | 0.82021 | 0.984252 | 0.492126 | 90 | 250x300-250x300
570611 | Level 1 | Level 2 | Level : Level 2 | -1.116 | Supply Air | Default Supply Air (cskender) | CR3-17 | 251 | 1.14829 | 0.82021 | 0.175957 | 18.5836 | 350x250-350x250
1118592 | 1D02 | Level 1 | Level : Level 1 | 3.3 | Return Air | Mechanical Return Air 1 | CR3-1 | 878 | 0.492126 | 0.82021 | 0.328084 | 90 | 150x250-150x250
1090969 | 2C18 | Level 2 | Level : Level 2 | 4 | Return Air | Mechanical Return Air 2 | CR3-1 | 257 | 0.82021 | 0.984252 | 0.492126 | 90 | 250x300-250x300
1119223 | 1C01 | Level 1 | Level : Level 1 | 3.70948 | Supply Air | Mechanical Supply Air 1 | SR3-1 | 926 | 0.82021 | 0.656168 | 0.492126 | 90 | 250x200-250x200
1138599 | 1B07 | Level 1 | Level : Level 1 | 3.3 | Return Air | Mechanical Return Air 1 | CR3-1 | 1484 | 0.164042 | 0.656168 | 0.164042 | 90 | 50x200-50x200
1138669 | 1B03 | Level 1 | Level : Level 1 | 3.3 | Return Air | Mechanical Return Air 1 | CR3-1 | 1504 | 0.656168 | 0.656168 | 0.410105 | 90 | 200x200-200x200
1137565 | 1D09 | Level 1 | Level : Level 1 | 3.3095 | Supply Air | Mechanical Supply Air 1 | SR3-1 | 1321 | 0.82021 | 0.82021 | 0.492126 | 90 | 250x250-250x250
1114059 | 2D02 | Level 2 | Level : Level 2 | 4 | Return Air | Mechanical Return Air 2 | CR3-1 | 677 | 0.984252 | 0.984252 | 0.574147 | 90 | 300x300-300x300
1138730 | 1B01 | Level 1 | Level : Level 1 | 3.3 | Return Air | Mechanical Return Air 1 | CR3-1 | 1517 | 0.492126 | 0.492126 | 0.328084 | 90 | 150x150-150x150
1138844 | 1A05 | Level 1 | Level : Level 1 | 3.245 | Return Air | Mechanical Return Air 1 | CR3-1 | 1545 | 0.492126 | 0.82021 | 0.328084 | 90 | 150x250-150x250
570796 | 1B19 | Level 1 | Level : Level 1 | 3.79 | Supply Air | Mechanical Supply Air 1 | SR3-1 | 731 | 0.984252 | 0.984252 | 0.574147 | 90 | 300x300-300x300
1138461 | 1E08 | Level 1 | Level : Level 1 | 3.3 | Return Air | Mechanical Return Air 1 | CR3-1 | 1440 | 0.492126 | 0.82021 | 0.328084 | 90 | 150x250-150x250
1138537 | 1B08 | Level 1 | Level : Level 1 | 3.3 | Return Air | Mechanical Return Air 1 | CR3-1 | 1462 | 0.492126 | 0.492126 | 0.328084 | 90 | 150x150-150x150
1138789 | 1A14 | Level 1 | Level : Level 1 | 3.245 | Return Air | Mechanical Return Air 1 | CR3-1 | 1532 | 0.492126 | 0.492126 | 0.328084 | 90 | 150x150-150x150
1137570 | 1D09 | Level 1 | Level : Level 1 | 3.70948 | Supply Air | Mechanical Supply Air 1 | SR3-1 | 1325 | 0.82021 | 0.82021 | 0.492126 | 90 | 250x250-250x250
570687 | 1A16 | Level 2 | Level : Level 2 | -1.325 | Return Air | Mechanical Return Air 1 |  | 482 | 0.82021 | 1.80446 | 0.251892 | 45 | 250x550-250x550
570649 | 1DC2 | Level 2 | Level : Level 2 | -0.860489 | Supply Air | Default Supply Air (cskender) | CR3-17 | 343 | 0.82021 | 0.984252 | 0.251888 | 44.9991 | 250x300-250x300
570590 | 1A16 | Level 2 | Level : Level 2 | -1.27 | Supply Air | Mechanical Supply Air 1 | SR3-1 | 149 | 0.82021 | 0.984252 | 0.492126 | 90 | 250x300-250x300
1138812 | 1A15 | Level 1 | Level : Level 1 | 3.245 | Return Air | Mechanical Return Air 1 | CR3-1 | 1536 | 0.492126 | 0.492126 | 0.328084 | 90 | 150x150-150x150
1138928 | 1D11 | Level 1 | Level : Level 1 | 3.3 | Return Air | Mechanical Return Air 1 | CR3-1 | 1569 | 0.492126 | 0.82021 | 0.328084 | 90 | 150x250-150x250
570794 | 1B19 | Level 1 | Level : Level 1 | 3.2 | Supply Air | Mechanical Supply Air 1 | SR3-1 | 724 | 0.984252 | 0.984252 | 0.574147 | 90 | 300x300-300x300
570651 | 1DC2 | Level 2 | Level : Level 2 | -1.025 | Supply Air | Default Supply Air (cskender) | CR3-17 | 354 | 0.82021 | 0.984252 | 0.251892 | 45 | 250x300-250x300
1138887 | 1D07 | Level 1 | Level : Level 1 | 3.3 | Return Air | Mechanical Return Air 1 | CR3-1 | 1557 | 0.492126 | 0.82021 | 0.328084 | 90 | 150x250-150x250
1099606 | 1C05 | Level 1 | Level : Level 1 | 3.64 | Return Air | Mechanical Return Air 1 | CR3-1 | 378 | 0.492126 | 1.14829 | 0.328084 | 90 | 150x350-150x350

# IfcFlowFitting: Rectangular Elbow - Radius - 1.5 W (4)
Type - ElementType: Rectangular Elbow - Radius - 1.5 W
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Level: Level 1; Host: Level : Level 1
PSet_Revit_Mechanical - Lining Thickness: 0; Insulation Thickness: 0; Loss Method: 1
PSet_Revit_Type_Dimensions - Radius Multiplier: 1.5
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
Name (M_Rectangular Elbow - Radius:Rectangular Elbow - Radius - 1.5 W:Rectangular Elbow - Radius - 1.5 W:...) | In | Width = Lining Width = Insulation Width | Lining Height = Insulation Height = Height | Length1 | Center Radius | Angle (deg) | Size | Offset (m) | Mark | System Type | System Name
1118923 | 1DC7 | 0.492126 | 1.14829 | 0.197797 | 0.738189 | 30 | 150x350-150x350 | 3.715 | 889 | Return Air | Mechanical Return Air 1 | PSet_Revit_Mechanical - ASHRAE Table: CR3-17
1112493 | 1D25 | 0.82021 | 0.984252 | 0.0259617 | 1.23031 | 2.41772 | 250x300-250x300 | 3.2905 | 635 | Supply Air | Mechanical Supply Air 1
1112488 | 1D25 | 0.82021 | 0.984252 | 0.0259617 | 1.23031 | 2.41772 | 250x300-250x300 | 3.28102 | 628 | Supply Air | Mechanical Supply Air 1
1118932 | 1DC7 | 0.492126 | 1.14829 | 0.197797 | 0.738189 | 30 | 150x350-150x350 | 3.4 | 898 | Return Air | Mechanical Return Air 1 | PSet_Revit_Mechanical - ASHRAE Table: CR3-17

# IfcFlowFitting: Rectangular Oval Transition - Length, M_Rectangular to Oval Transition - Length:Rectangular Oval Transition - Length:Rectangular Oval Transition - Length:1114444
In: 2D05
Type - ElementType: Rectangular Oval Transition - Length
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
PSet_Revit_Other - Offset Width 1: 10; Vertical Profile Offset 2: 0.246063; Vertical Profile Offset 1: 0.410105; Vertical Profile Offset: 0; Offset Height 1: 10; Half Width 2: 2.46063; Half Width 1: 1.14829; Half Height 2: 0.82021; Half Height 1: 0.492126; Horizontal Profile Offset: 0; TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Lining Thickness: 0; Insulation Thickness: 0; System Type: Supply Air; System Name: Mechanical Supply Air 1; Loss Method: 1
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Dimensions - Duct Width 2: 4.92126; Duct Width 1: 2.29659; Lining Width 2: 4.92126; Lining Width 1: 2.29659; Lining Height 2: 1.64042; Lining Height 1: 0.984252; Duct Length: 0.984252; Insulation Width 2: 4.92126; Insulation Width 1: 2.29659; Insulation Height 2: 1.64042; Insulation Height 1: 0.984252; Duct Height 2: 1.64042; Duct Height 1: 0.984252; Size: 1500/500-700x300; OffsetHeight: 0.492126; OffsetWidth: 1.14829
PSet_Revit_Identity Data - Mark: 694
PSet_Revit_Constraints - Level: Level 2; Host: Level : Level 2; Offset: 3.2 m

# IfcFlowFitting: Rectangular Takeoff (25)
Type - ElementType: Rectangular Takeoff
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Length Multiplier: 0.25; ConnectorOffset: 0; Takeoff Length Projection: 0.02
PSet_Revit_Mechanical - Lining Thickness: 0; Insulation Thickness: 0; Loss Method: 1
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Rectangular Takeoff:Rectangular Takeoff:Rectangular Takeoff:...) | In | W1 = W0 = Lining Width = Insulation Width | Lining Height = Insulation Height = H1 = H0 | Size | Takeoff Fixed Length | Takeoff Length | System Type | System Name | Level | Host | Offset (m) | Mark
570663 | 1A16 | 0.82021 | 0.492126 | 250x150-250x150 | 0.328084 | 0.328084 | Supply Air | Default Supply Air (cskender) | Level 2 | Level : Level 2 | -1.116 | 406
1094236 | 1D25 | 4.42913 | 1.47638 | 1350x450-1350x450 | 1.10728 | 1.10728 | Return Air | Mechanical Return Air 1 | Level 1 | Level : Level 1 | 3.64 | 313
1093987 | 1D24 | 7.54593 | 1.9685 | 2300x600-2300x600 | 1.88648 | 1.88648 | Return Air | Mechanical Return Air 1 | Level 1 | Level : Level 1 | 3.94 | 292
1094364 | 2D05 | 4.92126 | 7.87402 | 1500x2400-1500x2400 | 1.23031 | 1.23031 | Return Air | Mechanical Return Air 1 | Level 2 | Level : Level 2 | 0.9 | 327
570677 | 1AC5 | 0.82021 | 0.492126 | 250x150-250x150 | 0.328084 | 0.328084 | Supply Air | Default Supply Air (cskender) | Level 2 | Level : Level 2 | -1.116 | 458
570669 | 1A16 | 0.82021 | 0.492126 | 250x150-250x150 | 0.328084 | 0.328084 | Supply Air | Default Supply Air (cskender) | Level 2 | Level : Level 2 | -1.116 | 425
1094514 | 2D05 | 2.29659 | 1.14829 | 700x350-700x350 | 0.574147 | 0.574147 | Return Air | Mechanical Return Air 1 | Level 2 | Level : Level 2 | 1.65 | 338
570631 | 1D08 | 0.656168 | 0.82021 | 200x250-200x250 | 0.328084 | 0.328084 | Supply Air | Default Supply Air (cskender) | Level 2 | Level : Level 2 | -1.025 | 300
570633 | 1D01 | 0.656168 | 0.82021 | 200x250-200x250 | 0.328084 | 0.328084 | Supply Air | Default Supply Air (cskender) | Level 2 | Level : Level 2 | -1.025 | 308
570637 | 1D02 | 0.656168 | 0.82021 | 200x250-200x250 | 0.328084 | 0.328084 | Supply Air | Default Supply Air (cskender) | Level 2 | Level : Level 2 | -1.025 | 325
570655 | 1AC2 | 0.82021 | 0.492126 | 250x150-250x150 | 0.328084 | 0.328084 | Supply Air | Default Supply Air (cskender) | Level 2 | Level : Level 2 | -1.025 | 374
1114062 | 2D02 | 0.984252 | 0.984252 | 300x300-300x300 | 0.328084 | 0.328084 | Return Air | Mechanical Return Air 2 | Level 2 | Level : Level 2 | 4 | 680
570671 | 1A01 | 0.82021 | 0.492126 | 250x150-250x150 | 0.328084 | 0.328084 | Supply Air | Default Supply Air (cskender) | Level 2 | Level : Level 2 | -1.116 | 433
570557 | 1CC1 | 0.984252 | 0.984252 | 300x300-300x300 | 0.328084 | 0.328084 | Return Air | Mechanical Return Air 1 | Level 1 | Level : Level 1 | 3.465 | 76
570653 | 1AC2 | 0.82021 | 0.492126 | 250x150-250x150 | 0.328084 | 0.328084 | Supply Air | Default Supply Air (cskender) | Level 2 | Level : Level 2 | -1.025 | 365
570614 | Level 1 | 0.82021 | 0.492126 | 250x150-250x150 | 0.328084 | 0.328084 | Supply Air | Default Supply Air (cskender) | Level 2 | Level : Level 2 | -1.116 | 262
570675 | 1A02 | 0.82021 | 0.492126 | 250x150-250x150 | 0.328084 | 0.328084 | Supply Air | Default Supply Air (cskender) | Level 2 | Level : Level 2 | -1.116 | 450
570650 | 1DC2 | 0.984252 | 0.82021 | 300x250-300x250 | 0.328084 | 0.328084 | Supply Air | Default Supply Air (cskender) | Level 2 | Level : Level 2 | -1.025 | 353
570673 | 1A01 | 0.82021 | 0.492126 | 250x150-250x150 | 0.328084 | 0.328084 | Supply Air | Default Supply Air (cskender) | Level 2 | Level : Level 2 | -1.116 | 441
570635 | 1D02 | 0.656168 | 0.82021 | 200x250-200x250 | 0.328084 | 0.328084 | Supply Air | Default Supply Air (cskender) | Level 2 | Level : Level 2 | -1.025 | 317
1112486 | 1D25 | 0.984252 | 0.82021 | 300x250-300x250 | 0.328084 | 0.430408 | Supply Air | Mechanical Supply Air 1 | Level 1 | Level : Level 1 | 3.28102 | 627
570603 | 1BC1 | 0.82021 | 0.492126 | 250x150-250x150 | 0.328084 | 0.328084 | Supply Air | Default Supply Air (cskender) | Level 2 | Level : Level 2 | -0.8645 | 214
995440 | 2D05 | 6.56168 | 2.78871 | 2000x850-2000x850 | 1.64042 | 1.64042 | Return Air | Mechanical Return Air 2 | Level 2 | Level : Level 2 | 1.65 | 81
570607 | 1B01 | 0.82021 | 0.492126 | 250x150-250x150 | 0.328084 | 0.328084 | Supply Air | Default Supply Air (cskender) | Level 2 | Level : Level 2 | -1.116 | 242
570605 | 1B02 | 0.82021 | 0.492126 | 250x150-250x150 | 0.328084 | 0.328084 | Supply Air | Default Supply Air (cskender) | Level 2 | Level : Level 2 | -0.8895 | 223

# IfcFlowFitting: Rectangular Tee (7)
Type - ElementType: Rectangular Tee
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Lining Thickness: 0; Insulation Thickness: 0; Loss Method: 1
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Shoulder: 0.082021
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
Name (M_Rectangular Tee:Rectangular Tee:Rectangular Tee:...) | In | System Type | System Name | Width3 = Lining Width3 = Insulation Width3 | Width = Lining Width = Insulation Width | Lining Height = Insulation Height = Height | Length3a | Length3 | Length1a | Length1 | Size | Level | Host | Offset (m) | Mark
1111589 | 1DC1 | Supply Air | Mechanical Supply Air 1 | 0.984252 | 0.492126 | 0.984252 | 0.246063 | 0.328084 | 0.492126 | 0.574147 | 300x300-150x300-150x300 | Level 1 | Level : Level 1 | 3.20948 | 505
570616 | 1B13 | Supply Air | Default Supply Air (cskender) | 0.82021 | 1.14829 | 0.82021 | 0.574147 | 0.656168 | 0.410105 | 0.492126 | 350x250-350x250-250x250 | Level 1 | Level : Level 1 | 3.454 | 266
570694 | 1A16 | Supply Air | Default Supply Air (cskender) | 1.47638 | 1.31234 | 0.82021 | 0.656168 | 0.738189 | 0.738189 | 0.82021 | 450x250-400x250-400x250 | Level 2 | Level : Level 2 | -1.09 | 508
1138655 | 1B03 | Return Air | Mechanical Return Air 1 | 0.656168 | 0.984252 | 0.984252 | 0.492126 | 0.574147 | 0.328084 | 0.410105 | 300x300-300x300-200x300 | Level 1 | Level : Level 1 | 3.3 | 1489
570627 | 1BC2 | Supply Air | Default Supply Air (cskender) | 1.14829 | 1.14829 | 0.82021 | 0.574147 | 0.656168 | 0.574147 | 0.656168 | 350x250-350x250-350x250 | Level 2 | Level : Level 2 | -1.116 | 284
1117451 | 1E27 | Supply Air | Mechanical Supply Air 1 | 0.984252 | 0.656168 | 0.984252 | 0.328084 | 0.410105 | 0.492126 | 0.574147 | 300x300-200x300-200x300 | Level 1 | Level : Level 1 | 3.5096 | 854
1112024 | 1DC1 | Return Air | Mechanical Return Air 1 | 2.13255 | 4.59318 | 1.9685 | 2.29659 | 2.37861 | 1.06627 | 1.14829 | 1400x600-1400x600-650x600 | Level 1 | Level : Level 1 | 3.64 | 611

# IfcFlowFitting: Rectangular Transition - 45 Degree (102)
Type - ElementType: Rectangular Transition - 45 Degree
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Mechanical - Lining Thickness: 0; Insulation Thickness: 0; Loss Method: 1
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
PSet_Revit_Type_Constraints - Angle: 45 deg
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Rectangular Transition - Angle:Rectangular Transition - 45 Degree:Rectangular Transition - 45 Degree:...) | In | Mark | System Type | System Name | ASHRAE Table | Level | Host | Offset (m) | Num8 | Num7 | Num6 | Num5 | Num4 | Num3 | Num2 | Num1 | Length 2 | Length 1 | Delta 2 | Delta 1 | WidthOffset | WidthDelta | Width2 = Lining Width 2 = Insulation Width 2 | Width1 = Lining Width 1 = Insulation Width 1 | MaxDelta = Length 01 = Computed Length | Lining Height 2 = Insulation Height 2 = Height2 | Lining Height 1 = Insulation Height 1 = Height1 | HeightOffset | HeightDelta | Half Width 2 | Half Width 1 | Half Height 2 | Half Height 1 | Size | OffsetHeight | OffsetWidth
995163 | 1E16 | 62 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.40953 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0.198016 | 0.198016 | 0 | 0 | 10 | 0.164042 | 0.984252 | 1.14829 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.492126 | 0.574147 | 0.410105 | 0.492126 | 350x300-300x250 | 0.492126 | 0.574147
1110995 | 1D05 | 495 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.96196 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0.198016 | 0.198016 | 0 | 0 | 10 | 0.164042 | 0.492126 | 0.656168 | 0.198016 | 0.492126 | 0.492126 | 10 | 0 | 0.246063 | 0.328084 | 0.246063 | 0.246063 | 200x150-150x150 | 0.246063 | 0.328084
1111592 | 1DC1 | 506 | Supply Air | Mechanical Supply Air 1 |  | Level 1 | Level : Level 1 | 3.20948 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0.198016 | 0.198016 | 0 | 0 | 10 | 0 | 0.492126 | 0.492126 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.246063 | 0.410105 | 0.492126 | 150x300-150x250 | 0.492126 | 0.246063
1111594 | 1DC1 | 507 | Supply Air | Mechanical Supply Air 1 |  | Level 1 | Level : Level 1 | 3.20948 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0.198016 | 0.198016 | 0 | 0 | 10 | 0 | 0.492126 | 0.492126 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.246063 | 0.410105 | 0.492126 | 150x300-150x250 | 0.492126 | 0.246063
1121352 | 1B10 | 1167 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.5 | 2 | 4 | 2 | 2 | 4 | 16 | 4 | 4 | 0.792065 | 0.396032 | 0 | 0 | 10 | 0.656168 | 0.984252 | 0.328084 | 0.792065 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.164042 | 0.492126 | 0.328084 | 300x300-100x200 | 0.328084 | 0.164042
570601 | 1DC1 | 176 | Supply Air | Mechanical Supply Air 1 |  | Level 2 | Level : Level 2 | -1.0605 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0.594049 | 0.198016 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 0.82021 | 0.82021 | 10 | 0 | 0.246063 | 0.492126 | 0.410105 | 0.410105 | 300x250-150x250 | 0.410105 | 0.492126
1090134 | 1E16 | 218 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 2.5 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0.396032 | 0.198016 | 0 | 0 | 10 | 0.328084 | 0.984252 | 1.31234 | 0.396032 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.492126 | 0.656168 | 0.410105 | 0.492126 | 400x300-300x250 | 0.492126 | 0.656168
1138354 | 1C19 | 1410 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.08267 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0.594049 | 0.198016 | 0 | 0 | 10 | 0.492126 | 0.656168 | 1.14829 | 0.594049 | 0.656168 | 0.492126 | 10 | 0.164042 | 0.328084 | 0.574147 | 0.328084 | 0.246063 | 350x150-200x200 | 0.246063 | 0.574147
1112031 | 1DC1 | 617 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.79 | 6 | 36 | -7.58007e-13 | 12 | 1 | 1 | 1 | 1 | 0.198016 | 0.984252 | 0.492126 | 0 | 10 | 0 | 2.13255 | 2.13255 | 0.984252 | 1.9685 | 0.984252 | 9.50787 | 0.984252 | 1.06627 | 1.06627 | 0.984252 | 0.492126 | 650x600-650x300 | -6.21725e-14 | 1.06627
1116398 | 2C19 | 806 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 2 | Level : Level 2 | 2.675 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0.396032 | 0.198016 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.492126 | 0.328084 | 0.410105 | 0.492126 | 300x250-200x300 | 0.492126 | 0.328084
1138335 | 1C17 | 1401 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.08267 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0.594049 | 0.198016 | 0 | 0 | 10 | 0.492126 | 0.656168 | 1.14829 | 0.594049 | 0.656168 | 0.492126 | 10 | 0.164042 | 0.328084 | 0.574147 | 0.328084 | 0.246063 | 350x150-200x200 | 0.246063 | 0.574147
570618 | 1B13 | 270 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.454 | 2 | 4 | 2 | 2 | 1 | 1 | 1 | 1 | 0.198016 | 0.396032 | 0 | 0 | 10 | 0 | 0.82021 | 0.82021 | 0.396032 | 0.492126 | 0.82021 | 10 | 0.328084 | 0.410105 | 0.410105 | 0.246063 | 0.410105 | 250x250-250x150 | 0.410105 | 0.410105
570610 | 1B13 | 250 | Supply Air | Default Supply Air (cskender) |  | Level 1 | Level : Level 1 | 3.454 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0.198016 | 0.198016 | 0.182087 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.0833333 | 0.82021 | 0.82021 | 10.1821 | 0 | 0.574147 | 0.574147 | 0.410105 | 0.410105 | 350x250-350x250 | 0.592192 | 0.574147
1090760 | 1E14 | 243 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0.198016 | 0.594049 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126 | 300x300-350x150 | 0.492126 | 0.492126
1138393 | Level 2 | 1430 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 3 | 9 | 3 | 3 | 3 | 9 | 3 | 3 | 0.594049 | 0.594049 | 0 | 0 | 10 | 0.492126 | 0.984252 | 0.492126 | 0.594049 | 0.984252 | 0.492126 | 10 | 0.492126 | 0.492126 | 0.246063 | 0.492126 | 0.246063 | 300x300-150x150 | 0.246063 | 0.246063
1138600 | 1B07 | 1485 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.12929 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0.396032 | 0.198016 | 0 | 0 | 10 | 0.328084 | 0.164042 | 0.492126 | 0.396032 | 0.656168 | 0.492126 | 10 | 0.164042 | 0.082021 | 0.246063 | 0.328084 | 0.246063 | 150x150-50x200 | 0.246063 | 0.246063
1138373 | 1C15 | 1416 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.08267 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0.594049 | 0.198016 | 0 | 0 | 10 | 0.492126 | 0.656168 | 1.14829 | 0.594049 | 0.656168 | 0.492126 | 10 | 0.164042 | 0.328084 | 0.574147 | 0.328084 | 0.246063 | 350x150-200x200 | 0.246063 | 0.574147
1096197 | 1E27 | 361 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.02231 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0.396032 | 0.198016 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.492126 | 0.492126 | 10 | 0 | 0.246063 | 0.410105 | 0.246063 | 0.246063 | 250x150-150x150 | 0.246063 | 0.410105
1138289 | 2D08 | 1367 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1118593 | 1D02 | 879 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.01893 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0.594049 | 0.198016 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.410105 | 0.492126 | 300x300-150x250 | 0.492126 | 0.492126
570619 | Level 1 | 271 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 2 | Level : Level 2 | -1.116 | 3 | 9 | 3 | 3 | 11 | 121 | 11 | 11 | 2.17818 | 0.594049 | 0 | 0 | 10 | 1.80446 | 2.62467 | 0.82021 | 2.17818 | 0.984252 | 0.492126 | 10 | 0.492126 | 1.31234 | 0.410105 | 0.492126 | 0.246063 | 800x300-250x150 | 0.246063 | 0.410105
1138759 | 1B10 | 1525 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.3 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0.594049 | 0.198016 | 0 | 0 | 10 | 0.492126 | 1.14829 | 0.656168 | 0.594049 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.574147 | 0.328084 | 0.246063 | 0.328084 | 350x150-200x200 | 0.328084 | 0.328084
570612 | 1B13 | 252 | Supply Air | Default Supply Air (cskender) |  | Level 2 | Level : Level 2 | -1.116 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0.198016 | 0.198016 | 0.182087 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.0833333 | 0.82021 | 0.82021 | 10.1821 | 0 | 0.574147 | 0.574147 | 0.410105 | 0.410105 | 350x250-350x250 | 0.592192 | 0.574147
1090970 | 2C18 | 258 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0.396032 | 0.198016 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.492126 | 0.328084 | 0.410105 | 0.328084 | 300x250-200x200 | 0.328084 | 0.328084
1090840 | 1E19 | 246 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0.396032 | 0.198016 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.492126 | 0.328084 | 0.410105 | 0.328084 | 300x250-200x200 | 0.328084 | 0.328084
1138462 | 1E08 | 1441 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0.198016 | 0.198016 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.656168 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.410105 | 0.328084 | 0.246063 | 0.328084 | 200x200-250x150 | 0.328084 | 0.328084
1138285 | 2C22 | 1359 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138276 | 1C10 | 1346 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138391 | 1BC2 | 1428 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 3 | 9 | 3 | 3 | 3 | 9 | 3 | 3 | 0.594049 | 0.594049 | 0 | 0 | 10 | 0.492126 | 0.984252 | 0.492126 | 0.594049 | 0.984252 | 0.492126 | 10 | 0.492126 | 0.492126 | 0.246063 | 0.492126 | 0.246063 | 300x300-150x150 | 0.246063 | 0.246063
1138392 | 1E23 | 1429 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 3 | 9 | 3 | 3 | 3 | 9 | 3 | 3 | 0.594049 | 0.594049 | 0 | 0 | 10 | 0.492126 | 0.984252 | 0.492126 | 0.594049 | 0.984252 | 0.492126 | 10 | 0.492126 | 0.492126 | 0.246063 | 0.492126 | 0.246063 | 300x300-150x150 | 0.246063 | 0.246063
1138387 | 1D19 | 1424 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 3 | 9 | 3 | 3 | 3 | 9 | 3 | 3 | 0.594049 | 0.594049 | 0 | 0 | 10 | 0.492126 | 0.984252 | 0.492126 | 0.594049 | 0.984252 | 0.492126 | 10 | 0.492126 | 0.492126 | 0.246063 | 0.492126 | 0.246063 | 300x300-150x150 | 0.246063 | 0.246063
1138302 | 2B10 | 1384 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
570922 | 1E07 | 9 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.08267 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0.594049 | 0.198016 | 0 | 0 | 10 | 0.492126 | 0.656168 | 1.14829 | 0.594049 | 0.656168 | 0.492126 | 10 | 0.164042 | 0.328084 | 0.574147 | 0.328084 | 0.246063 | 350x150-200x200 | 0.246063 | 0.574147
1138388 | 1D15 | 1425 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 3 | 9 | 3 | 3 | 3 | 9 | 3 | 3 | 0.594049 | 0.594049 | 0 | 0 | 10 | 0.492126 | 0.984252 | 0.492126 | 0.594049 | 0.984252 | 0.492126 | 10 | 0.492126 | 0.492126 | 0.246063 | 0.492126 | 0.246063 | 300x300-150x150 | 0.246063 | 0.246063
1138381 | 1E22 | 1417 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 3 | 9 | 3 | 3 | 3 | 9 | 3 | 3 | 0.594049 | 0.594049 | 0 | 0 | 10 | 0.492126 | 0.984252 | 0.492126 | 0.594049 | 0.984252 | 0.492126 | 10 | 0.492126 | 0.492126 | 0.246063 | 0.492126 | 0.246063 | 300x300-150x150 | 0.246063 | 0.246063
1138306 | 2D03 | 1388 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138286 | 2C01 | 1360 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138305 | 2D01 | 1387 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138538 | 1B08 | 1463 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.3 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0.198016 | 0.198016 | 0 | 0 | 10 | 0.164042 | 0.656168 | 0.492126 | 0.198016 | 0.656168 | 0.492126 | 10 | 0.164042 | 0.328084 | 0.246063 | 0.328084 | 0.246063 | 200x200-150x150 | 0.246063 | 0.246063
1138283 | 1E25 | 1357 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1119818 | 1E16 | 1026 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.40953 | 2 | 4 | 2 | 2 | 1.5 | 2.25 | 1.5 | 1.5 | 0.297024 | 0.396032 | 0 | 0 | 10 | 0.246063 | 1.39436 | 1.14829 | 0.396032 | 1.14829 | 0.82021 | 10 | 0.328084 | 0.697178 | 0.574147 | 0.574147 | 0.410105 | 425x350-350x250 | 0.410105 | 0.574147
1090518 | 1B23 | 233 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0.198016 | 0.198016 | 0 | 0 | 10 | 0.164042 | 0.656168 | 0.492126 | 0.198016 | 0.328084 | 0.492126 | 10 | 0.164042 | 0.328084 | 0.246063 | 0.164042 | 0.246063 | 150x150-200x100 | 0.246063 | 0.246063
1138301 | 2B14 | 1383 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138384 | 1A03 | 1421 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 3 | 9 | 3 | 3 | 3 | 9 | 3 | 3 | 0.594049 | 0.594049 | 0 | 0 | 10 | 0.492126 | 0.984252 | 0.492126 | 0.594049 | 0.984252 | 0.492126 | 10 | 0.492126 | 0.492126 | 0.246063 | 0.492126 | 0.246063 | 300x300-150x150 | 0.246063 | 0.246063
1116595 | 2AC1 | 817 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 2 | Level : Level 2 | 2.8 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0.594049 | 0.198016 | 0 | 0 | 10 | 0.492126 | 0.82021 | 1.31234 | 0.594049 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.410105 | 0.656168 | 0.410105 | 0.492126 | 400x300-250x250 | 0.492126 | 0.656168
1138287 | 2A10 | 1364 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138309 | 2A12 | 1392 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138273 | 1C16 | 1343 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138389 | 1D30 | 1426 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 3 | 9 | 3 | 3 | 3 | 9 | 3 | 3 | 0.594049 | 0.594049 | 0 | 0 | 10 | 0.492126 | 0.984252 | 0.492126 | 0.594049 | 0.984252 | 0.492126 | 10 | 0.492126 | 0.492126 | 0.246063 | 0.492126 | 0.246063 | 300x300-150x150 | 0.246063 | 0.246063
1138307 | 2D02 | 1389 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138308 | 2AC5 | 1391 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1094188 | 1D25 | 299 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.64 | 7 | 49 | 2.49059e-13 | 14 | 14 | 196 | 14 | 14 | 2.77223 | 1.14829 | 0.574147 | 0 | 10 | 2.29659 | 2.29659 | 4.59318 | 2.77223 | 0.82021 | 1.9685 | 10.5741 | 1.14829 | 1.14829 | 2.29659 | 0.410105 | 0.984252 | 1400x600-700x250 | 1.5584 | 2.29659
1094362 | 2D05 | 322 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | 0.9 | 1 | 1 | 1 | 1 | 10 | 100 | 10 | 10 | 1.98016 | 0.198016 | 0 | 0 | 10 | 1.64042 | 7.87402 | 9.51444 | 1.98016 | 4.92126 | 4.92126 | 10 | 0 | 3.93701 | 4.75722 | 2.46063 | 2.46063 | 2900x1500-2400x1500 | 2.46063 | 4.75722
1138731 | 1B01 | 1518 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.3 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0.396032 | 0.198016 | 0 | 0 | 10 | 0.328084 | 0.82021 | 0.492126 | 0.396032 | 0.492126 | 0.492126 | 10 | 0 | 0.410105 | 0.246063 | 0.246063 | 0.246063 | 250x150-150x150 | 0.246063 | 0.246063
1138269 | 1D08 | 1339 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1120471 | 1C07 | 1118 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.08267 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0.594049 | 0.198016 | 0 | 0 | 10 | 0.492126 | 0.656168 | 1.14829 | 0.594049 | 0.656168 | 0.656168 | 10 | 0 | 0.328084 | 0.574147 | 0.328084 | 0.328084 | 350x200-200x200 | 0.328084 | 0.574147
1138280 | 1D24 | 1351 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138296 | 2B24 | 1378 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138813 | 1A15 | 1537 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.245 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0.198016 | 0.198016 | 0 | 0 | 10 | 0.164042 | 0.656168 | 0.492126 | 0.198016 | 0.656168 | 0.492126 | 10 | 0.164042 | 0.328084 | 0.246063 | 0.328084 | 0.246063 | 200x200-150x150 | 0.246063 | 0.246063
1138277 | 1A01 | 1347 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1120442 | 1D09 | 1111 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.3 | 1 | 1 | 1 | 1 | 4 | 16 | 4 | 4 | 0.792065 | 0.198016 | 0 | 0 | 10 | 0.656168 | 1.80446 | 1.14829 | 0.792065 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.902231 | 0.574147 | 0.410105 | 0.328084 | 550x250-350x200 | 0.328084 | 0.574147
1138274 | 1C05 | 1344 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1113852 | 2C17 | 665 | Supply Air | Mechanical Supply Air 2 |  | Level 2 | Level : Level 2 | 3.4095 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0.594049 | 0.198016 | 0 | 0 | 10 | 0.492126 | 0.656168 | 1.14829 | 0.594049 | 1.14829 | 1.14829 | 10 | 0 | 0.328084 | 0.574147 | 0.574147 | 0.574147 | 350x350-200x350 | 0.574147 | 0.574147
1138265 | 1D34 | 1335 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138660 | 1B03 | 1492 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.3 | 2 | 4 | 2 | 2 | 1 | 1 | 1 | 1 | 0.198016 | 0.396032 | 0 | 0 | 10 | 0 | 0.656168 | 0.656168 | 0.396032 | 0.656168 | 0.984252 | 10 | 0.328084 | 0.328084 | 0.328084 | 0.328084 | 0.492126 | 200x300-200x200 | 0.492126 | 0.328084
1138297 | 2B7 | 1379 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138304 | 2BC1 | 1386 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138268 | 1E05 | 1338 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138282 | 1E18 | 1353 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138295 | 2B19 | 1377 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138310 | 1D10 | 1393 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138790 | 1A14 | 1533 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.245 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0.198016 | 0.198016 | 0 | 0 | 10 | 0.164042 | 0.656168 | 0.492126 | 0.198016 | 0.492126 | 0.492126 | 10 | 0 | 0.328084 | 0.246063 | 0.246063 | 0.246063 | 200x150-150x150 | 0.246063 | 0.246063
1138929 | 1D11 | 1571 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.13964 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0.198016 | 0.198016 | 0 | 0 | 10 | 0.164042 | 0.492126 | 0.656168 | 0.198016 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.246063 | 0.328084 | 0.410105 | 0.328084 | 200x200-150x250 | 0.328084 | 0.328084
1138267 | 1E04 | 1337 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138284 | 2A02 | 1358 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138299 | 2B17 | 1381 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
570788 | 2D05 | 716 | Return Air | Mechanical Return Air 2 |  | Roof - Main | Level : Roof - Main | -1.06378 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0.198016 | 0.198016 | 0.274853 | 0 | 10 | 0 | 4.26509 | 4.26509 | 0.0833333 | 3.28084 | 3.28084 | 10.2749 | 0 | 2.13255 | 2.13255 | 1.64042 | 1.64042 | 1300x1000-1300x1000 | 1.91527 | 2.13255
1138272 | 1C14 | 1342 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138293 | 2D17 | 1372 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138288 | 2D09 | 1366 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138263 | 1D35 | 1333 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138845 | 1A05 | 1546 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.08464 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0.198016 | 0.198016 | 0 | 0 | 10 | 0.164042 | 0.492126 | 0.656168 | 0.198016 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.246063 | 0.328084 | 0.410105 | 0.328084 | 200x200-150x250 | 0.328084 | 0.328084
570789 | 2D05 | 717 | Return Air | Mechanical Return Air 2 |  | Roof - Main | Level : Roof - Main | -0.98 | 10 | 100 | -3.68175e-13 | 20 | 2 | 4 | 1.08287e-13 | 4 | 0.328084 | 1.64042 | 0.82021 | 0.164042 | 9.83596 | 0.328084 | 3.93701 | 4.26509 | 1.64042 | 1.64042 | 3.28084 | 10.8202 | 1.64042 | 1.9685 | 2.13255 | 0.82021 | 1.64042 | 1300x1000-1200x500 | 2.46063 | 1.9685
1138278 | 1D40 | 1348 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138264 | 1D32 | 1334 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138888 | 1D07 | 1558 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.13964 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0.198016 | 0.198016 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.656168 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.410105 | 0.328084 | 0.246063 | 0.328084 | 200x200-250x150 | 0.328084 | 0.328084
1138303 | 2B8 | 1385 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138294 | 2B18 | 1376 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138275 | 1A04 | 1345 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138261 | 1D13 | 1331 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138266 | 1D27 | 1336 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138279 | 1D33 | 1350 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138290 | 2D07 | 1368 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138260 | 1D02 | 1330 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138300 | 2B15 | 1382 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138298 | 2B4 | 1380 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
570792 | 1DC7 | 721 | Return Air | Mechanical Return Air 1 |  | Level 1 | Level : Level 1 | 3.715 | 3 | 9 | -7.03864e-13 | 6 | 7 | 49 | 7 | 7 | 1.38611 | 0.492126 | 0.246063 | 0 | 10 | 1.14829 | 4.42913 | 3.28084 | 1.38611 | 1.47638 | 0.984252 | 9.75394 | 0.492126 | 2.21457 | 1.64042 | 0.738189 | 0.492126 | 1350x450-1000x300 | 0.246063 | 1.64042
1138258 | 1A07 | 1328 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138292 | 2D16 | 1371 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1138291 | 2D11 | 1370 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
