Properties of the parts of a building model (IFC2X3), part 4 of 295

# IfcSpace (526)
Name | In | LongName = Name | Area (m2) = GSA BIM Area (m2) | Perimeter (m) | Unbounded Height (m) | Volume (m3) | Level | Upper Limit | Limit Offset (m) | Base Offset (m) | Category Description | Category Code | CirculationZoneName | FireAlarmZoneName | HistoricPreservationZoneName | LightingZoneName | OccupancyZoneName | VentilationZoneName | Number | OmniClass Table 13 Category | RoomTag
1D25-M | Level 1 | PROVIDER CUBICLES | 65.1999 | 35.918 | 4 | 260.8 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D25-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 41.4947; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 16.5979; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 2.64152; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D25; Room Name: PROVIDER CUBICLES; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B05-M | Level 1 | PAT. / STAFF TOILET | 4.21724 | 8.292 | 4 | 16.869 | Level 1 | Level 1 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B05-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 9.428; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B05; Room Name: PAT. / STAFF TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D20-M | Level 1 | APPMTS | 10.9544 | 13.244 | 4 | 43.8178 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D20-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.79719; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D20; Room Name: APPMTS; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C16-M | Level 2 | CERAMIC LAB | 10.1378 | 13.236 | 4 | 40.5514 | Level 2 | Level 2 | 4 | 0 | Laboratory | 13-15 11 24 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C16-M | 13-15 11 24 11: Laboratory | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.26037; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C16; Room Name: CERAMIC LAB; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1A11-M | Level 1 | JAN. | 1.67862 | 5.526 | 4 | 6.71449 | Level 1 | Level 1 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A11-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 16.7727; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1A11; Room Name: JAN.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1ES2-M | Level 1 | STAIR | 14.83 | 17.522 | 4 | 59.3201 | Level 1 | Level 1 | 4 | 0 | Stairway | 13-85 21 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1ES2-M | 13-85 21 11: Stairway | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 0; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1ES2; Room Name: STAIR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D30-M | Level 1 | WTS & MEAS. ROOM | 8.49505 | 12.176 | 4 | 33.9802 | Level 1 | Level 1 | 4 | 0 | Physical Examination Room | 13-41 41 14 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D30-M | 13-41 41 14: Physical Examination Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.8727; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D30; Room Name: WTS & MEAS. ROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C09-M | Level 2 | GEN. DENT. DTR #9 | 10.4598 | 11.4335 | 4 | 41.8393 | Level 2 | Level 2 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C09-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.24135; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C09; Room Name: GEN. DENT. DTR #9; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D19-M | Level 1 | MDIS VIEW | 5.11582 | 9.285 | 4 | 20.4633 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D19-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 8.70273; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D19; Room Name: MDIS VIEW; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1AC2-M | Level 1 | CORRIDOR | 19.0985 | 23.984 | 4 | 76.3939 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1AC2-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.08439; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1AC2; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B17-M | Level 2 | CL. UTL. / KITCHENET | 8.25739 | 11.676 | 4 | 33.0296 | Level 2 | Level 2 | 4 | 0 | Kitchen | 13-11 19 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B17-M | 13-11 19 11 11: Kitchen | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.78016; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B17; Room Name: CL. UTL. / KITCHENET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1C15-M | Level 1 | PES ADMIN. OFFICE | 14.578 | 15.344 | 4 | 58.312 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C15-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.04695; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C15; Room Name: PES ADMIN. OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1BC1-M | Level 1 | CORRIDOR | 5.0958 | 9.38 | 4 | 20.3832 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1BC1-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 8.82631; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1BC1; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1A08-M | Level 1 | PHARM. OFFICE | 9.5107 | 12.42 | 4 | 38.0428 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A08-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.26178; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1A08; Room Name: PHARM. OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E19-M | Level 1 | ELEC. ROOM | 8.88809 | 12.19 | 4 | 35.5524 | Level 1 | Level 1 | 4 | 0 | Electrical Room | 13-81 21 21 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E19-M | 13-81 21 21: Electrical Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.57634; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E19; Room Name: ELEC. ROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B15-M | Level 1 | FILM VIEW | 5.25326 | 9.168 | 4 | 21.0131 | Level 1 | Level 1 | 4 | 0 | Scanning/Imaging Room | 13-41 41 31 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B15-M | 13-41 41 31: Scanning/Imaging Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 8.36824; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B15; Room Name: FILM VIEW; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E25-M | Level 1 | ADP EQUIP SPACE | 10.5609 | 13.5028 | 4 | 42.2435 | Level 1 | Level 1 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E25-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.13073; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E25; Room Name: ADP EQUIP SPACE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2A08-M | Level 2 | GEN. DENT. DTR #4 | 10.8317 | 11.5343 | 4 | 43.3266 | Level 2 | Level 2 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A08-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.10606; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2A08; Room Name: GEN. DENT. DTR #4; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1C05-M | Level 1 | VISUAL FIELD | 10.1045 | 13.756 | 4 | 40.418 | Level 1 | Level 1 | 4 | 0 | Physical Examination Room | 13-41 41 14 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C05-M | 13-41 41 14: Physical Examination Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.52779; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C05; Room Name: VISUAL FIELD; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B5-M | Level 2 | W. TOILET | 4.13091 | 8.436 | 4 | 16.5236 | Level 2 | Level 2 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B5-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 9.79218; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B5; Room Name: W. TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D13-M | Level 2 | TOILET | 4.18311 | 8.516 | 4 | 16.7324 | Level 2 | Level 2 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D13-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 10.0671; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D13; Room Name: TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1C16-M | Level 1 | ECG TEST | 9.03638 | 12.816 | 4 | 36.1455 | Level 1 | Level 1 | 4 | 0 | Scanning/Imaging Room | 13-41 41 31 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C16-M | 13-41 41 31: Scanning/Imaging Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.80059; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C16; Room Name: ECG TEST; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1DC5-M | Level 1 | CORRIDOR | 6.07324 | 10.4294 | 4 | 24.2929 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1DC5-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 8.23434; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1DC5; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B13-M | Level 1 | RECEPTION | 21.4604 | 21.604 | 4 | 85.8415 | Level 1 | Level 1 | 4 | 0 | Reception Space | 13-11 11 31 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B13-M | 13-11 11 31: Reception Space | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 24.8968; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.8271; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B13; Room Name: RECEPTION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C17-M | Level 2 | PROSTH. LAB | 28.5857 | 24.644 | 4 | 114.343 | Level 2 | Level 2 | 4 | 0 | Laboratory | 13-15 11 24 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C17-M | 13-15 11 24 11: Laboratory | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 24.8968; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.13382; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C17; Room Name: PROSTH. LAB; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1BC3-M | Level 1 | CORRIDOR | 12.4249 | 17.9521 | 4 | 49.6996 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1BC3-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.92803; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1BC3; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E22-M | Level 1 | SEC. STORAGE | 5.64193 | 9.928 | 4 | 22.5677 | Level 1 | Level 1 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E22-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 8.43768; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E22; Room Name: SEC. STORAGE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2DC1-M | Level 2 | CORRIDOR | 20.1438 | 26.8624 | 4 | 80.5752 | Level 2 | Level 2 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2DC1-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.3943; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2DC1; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B24-M | Level 2 | BEE TECH | 8.82448 | 12.031 | 4 | 35.2979 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B24-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.53734; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B24; Room Name: BEE TECH; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1C09-M | Level 1 | FUNDUS CAMERA ROOM | 13.7718 | 15.688 | 4 | 55.0873 | Level 1 | Level 1 | 4 | 0 | Scanning/Imaging Room | 13-41 41 31 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C09-M | 13-41 41 31: Scanning/Imaging Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.46216; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C09; Room Name: FUNDUS CAMERA ROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B4-M | Level 2 | PSYCH TEST | 9.16922 | 12.184 | 4 | 36.6769 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B4-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.37157; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B4; Room Name: PSYCH TEST; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1EC3-M | Level 1 | CORRIDOR | 8.0541 | 12.84 | 4 | 32.2164 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1EC3-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.64428; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1EC3; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E02-M | Level 1 | ELEV. EQUIP. | 5.08627 | 9.256 | 4 | 20.3451 | Level 1 | Level 1 | 4 | 0 | Equipment Room | 13-81 21 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E02-M | 13-81 21 11: Equipment Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 9.27188; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E02; Room Name: ELEV. EQUIP.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2A02-M | Level 2 | SUPER OFFICE | 10.0234 | 13.462 | 4 | 40.0934 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A02-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.43999; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2A02; Room Name: SUPER OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2AS1-M | Level 2 | STAIR | 13.644 | 15.5331 | 4 | 54.576 | Level 2 | Level 2 | 4 | 0 | Stairway | 13-85 21 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2AS1-M | 13-85 21 11: Stairway | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.45891; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2AS1; Room Name: STAIR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E27-M | Level 1 | BENCHSTOCK STORAGE | 8.55171 | 10.8466 | 4 | 34.2068 | Level 1 | Level 1 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E27-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.08173; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E27; Room Name: BENCHSTOCK STORAGE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D37-M | Level 1 | CLEAN U. | 2.08844 | 6.012 | 4 | 8.35376 | Level 1 | Level 1 | 4 | 0 | Clean Room | 13-15 21 11 21 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D37-M | 13-15 21 11 21: Clean Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 0; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D37; Room Name: CLEAN U.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1C02-M | Level 1 | RECEPTION | 8.81864 | 11.9952 | 4 | 35.2745 | Level 1 | Level 1 | 4 | 0 | Reception Space | 13-11 11 31 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C02-M | 13-11 11 31: Reception Space | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.52222; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C02; Room Name: RECEPTION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B01-M | Level 1 | RECEPTION | 8.80829 | 12.292 | 4 | 35.2331 | Level 1 | Level 1 | 4 | 0 | Reception Space | 13-11 11 31 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B01-M | 13-11 11 31: Reception Space | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.69144; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B01; Room Name: RECEPTION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C01-M | Level 2 | DTR SUPPORT | 8.11544 | 11.532 | 4 | 32.4618 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C01-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.81367; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C01; Room Name: DTR SUPPORT; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1C18-M | Level 1 | PHYSICAL EXAM | 55.3775 | 40.225 | 4 | 221.51 | Level 1 | Level 1 | 4 | 0 | Physical Examination Room | 13-41 41 14 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C18-M | 13-41 41 14: Physical Examination Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 33.1958; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 16.5979; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 3.48298; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C18; Room Name: PHYSICAL EXAM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D17-M | Level 1 | JAN. CL. | 1.67126 | 5.3198 | 4 | 6.68503 | Level 1 | Level 1 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D17-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 15.263; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D17; Room Name: JAN. CL.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D03-M | Level 2 | DIR. INFO MGR | 8.72371 | 12.3975 | 4 | 34.8949 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D03-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.9209; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D03; Room Name: DIR. INFO MGR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B20-M | Level 2 | JAN. CL. | 2.82658 | 7.10712 | 4 | 11.3063 | Level 2 | Level 2 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B20-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 12.8108; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B20; Room Name: JAN. CL.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1C11-M | Level 1 | ELEC. CL. | 0.53976 | 4.084 | 4 | 2.15904 | Level 1 | Level 1 | 4 | 0 | Electrical Room | 13-81 21 21 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C11-M | 13-81 21 21: Electrical Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 0; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C11; Room Name: ELEC. CL.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D18-M | Level 1 | TOILET | 7.38736 | 12.3368 | 4 | 29.5495 | Level 1 | Level 1 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D18-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 8.17458; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D18; Room Name: TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B15-M | Level 2 | WAIT / ERGOM | 8.37408 | 11.744 | 4 | 33.4963 | Level 2 | Level 2 | 4 | 0 | Waiting Room | 13-51 31 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B15-M | 13-51 31 11: Waiting Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.72462; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B15; Room Name: WAIT / ERGOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2AC4-M | Level 2 | CORRIDOR | 13.4184 | 18.6881 | 4 | 53.6734 | Level 2 | Level 2 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2AC4-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.67812; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2AC4; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C06-M | Level 2 | GEN. DENT. DTR #8 | 10.9245 | 11.4335 | 4 | 43.698 | Level 2 | Level 2 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C06-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.0184; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C06; Room Name: GEN. DENT. DTR #8; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1DC6-M | Level 1 | CORRIDOR | 13.8859 | 19.7848 | 4 | 55.5435 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1DC6-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.83198; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1DC6; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B23-M | Level 2 | BEE TECH | 9.91341 | 12.657 | 4 | 39.6536 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B23-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.12204; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B23; Room Name: BEE TECH; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E12-M | Level 1 | ISOLATION TOILET | 4.65145 | 8.742 | 4 | 18.6058 | Level 1 | Level 1 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E12-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 9.01179; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E12; Room Name: ISOLATION TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1DC8-M | Level 1 | CORRIDOR | 5.87884 | 10.3589 | 4 | 23.5153 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1DC8-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 8.44909; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1DC8; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2A14-M | Level 2 | ADMIN | 31.5775 | 24.4173 | 4 | 126.31 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A14-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 3.70773; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2A14; Room Name: ADMIN; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C19-M | Level 2 | CENTRAL ISSUE | 19.8021 | 19.696 | 4 | 79.2084 | Level 2 | Level 2 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C19-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.76931; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C19; Room Name: CENTRAL ISSUE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B19-M | Level 1 | RADIOGRAPHIC ROOM | 28.2327 | 27.8608 | 4 | 112.931 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B19-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.73184; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B19; Room Name: RADIOGRAPHIC ROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
