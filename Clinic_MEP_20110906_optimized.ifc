Properties of the parts of a building model (IFC2X3), part 252 of 295

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:566982
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:566987
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:566987
PSet_Revit_Identity Data - Mark: 153
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.08267 m; Top Elevation: 3.53393 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.031436; Hydraulic Diameter: 0.984252; Section: 57; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.541522 m2
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.451268 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0392811; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.08267 m; Start Offset: 3.08267 m; End Offset: 3.53393 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567004
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567004
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 2.9016 m; Start Offset: 2.9016 m; End Offset: 3.01893 m
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.117334 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 2.9016 m; Top Elevation: 3.01893 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.00817365; Hydraulic Diameter: 0.984252; Section: 70; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.140801 m2
PSet_Revit_Identity Data - Mark: 156
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0102135; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567009
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567009
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 157
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0189181; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.217334 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 2.9016 m; Top Elevation: 3.11893 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0151398; Hydraulic Diameter: 0.984252; Section: 73; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.260801 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 2.9016 m; Start Offset: 2.9016 m; End Offset: 3.11893 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567011
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567011
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 20.5599; Friction: 0.220945; Pressure Drop: 0.1833; Velocity Pressure: 7.19746; Reynolds number: 78291.9
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.64 m; Start Offset: 3.64 m; End Offset: 3.64 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 158
PSet_Revit_Dimensions - Size: 250x150; Width: 0.82021; Height: 0.492126; Length: 0.252868 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.565 m; Top Elevation: 3.715 m; Equivalent Diameter: 0.688942; Size Lock: no; Loss Coefficient: 0.0254673; Hydraulic Diameter: 0.615157; Section: 78; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.202294 m2
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567012
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567012
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.02231 m; Top Elevation: 3.35893 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0234497; Hydraulic Diameter: 0.984252; Section: 77; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.403948 m2
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.336623 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0293017; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Identity Data - Mark: 159
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.02231 m; Start Offset: 3.02231 m; End Offset: 3.35893 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567014
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567014
PSet_Revit_Identity Data - Mark: 160
PSet_Revit_Dimensions - Size: 1350x450; Width: 4.42913; Height: 1.47638; Length: 0.990214 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.415 m; Top Elevation: 3.865 m; Equivalent Diameter: 2.69666; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 2.21457; Section: 275; Insulation Thickness: 0; Lining Thickness: 0; Area: 3.56477 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.64 m; Start Offset: 3.64 m; End Offset: 3.64 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567018
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567018
PSet_Revit_Identity Data - Mark: 161
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.64 m; Start Offset: 3.64 m; End Offset: 3.64 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 350x150; Width: 1.14829; Height: 0.492126; Length: 0.310416 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.565 m; Top Elevation: 3.715 m; Equivalent Diameter: 0.804054; Size Lock: no; Loss Coefficient: 0.029515; Hydraulic Diameter: 0.688976; Section: 204; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.310416 m2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 14.6857; Friction: 0.106423; Pressure Drop: 0.108384; Velocity Pressure: 3.67217; Reynolds number: 62633.6
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567020
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567020
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.64 m; Start Offset: 3.64 m; End Offset: 3.64 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 162
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.415 m; Top Elevation: 3.865 m; Equivalent Diameter: 2.69666; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 2.21457; Section: 276; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.950064 m2
PSet_Revit_Dimensions - Size: 1350x450; Width: 4.42913; Height: 1.47638; Length: 0.263907 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567023
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567023
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.02231 m; Top Elevation: 3.35893 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0234497; Hydraulic Diameter: 0.984252; Section: 85; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.403948 m2
PSet_Revit_Identity Data - Mark: 163
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.336623 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0293017; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.02231 m; Start Offset: 3.02231 m; End Offset: 3.35893 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567027
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567027
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.02231 m; Top Elevation: 3.35893 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0234497; Hydraulic Diameter: 0.984252; Section: 81; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.403948 m2
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.336623 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.02231 m; Start Offset: 3.02231 m; End Offset: 3.35893 m
PSet_Revit_Identity Data - Mark: 164
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0293017; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567032
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567032
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.64 m; Start Offset: 3.64 m; End Offset: 3.64 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 14.6857; Friction: 0.106423; Pressure Drop: 0.233192; Velocity Pressure: 3.67217; Reynolds number: 62633.6
PSet_Revit_Dimensions - Size: 350x150; Width: 1.14829; Height: 0.492126; Length: 0.667868 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.565 m; Top Elevation: 3.715 m; Equivalent Diameter: 0.804054; Size Lock: no; Loss Coefficient: 0.0635023; Hydraulic Diameter: 0.688976; Section: 89; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.667868 m2
PSet_Revit_Identity Data - Mark: 165
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567033
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567033
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.457334 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 2.9016 m; Top Elevation: 3.35893 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0318585; Hydraulic Diameter: 0.984252; Section: 88; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.548801 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 2.9016 m; Start Offset: 2.9016 m; End Offset: 3.35893 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0398091; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 166
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567035
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567035
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.64 m; Start Offset: 3.64 m; End Offset: 3.64 m; Slope: 0
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.415 m; Top Elevation: 3.865 m; Equivalent Diameter: 2.69666; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 2.21457; Section: 291; Insulation Thickness: 0; Lining Thickness: 0; Area: 5.904 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 167
PSet_Revit_Dimensions - Size: 1350x450; Width: 4.42913; Height: 1.47638; Length: 1.64 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567039
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567039
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 168
PSet_Revit_Dimensions - Size: 350x150; Width: 1.14829; Height: 0.492126; Length: 0.447868 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.565 m; Top Elevation: 3.715 m; Equivalent Diameter: 0.804054; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 0.688976; Section: 263; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.447868 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.64 m; Start Offset: 3.64 m; End Offset: 3.64 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567041
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567041
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.64 m; Start Offset: 3.64 m; End Offset: 3.64 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 1350x450; Width: 4.42913; Height: 1.47638; Length: 1.17117 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.415 m; Top Elevation: 3.865 m; Equivalent Diameter: 2.69666; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 2.21457; Section: 290; Insulation Thickness: 0; Lining Thickness: 0; Area: 4.21623 m2
PSet_Revit_Identity Data - Mark: 169
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567043
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567043
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 250x150; Width: 0.82021; Height: 0.492126; Length: 0.202868 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 20.5599; Friction: 0.220945; Pressure Drop: 0.147056; Velocity Pressure: 7.19746; Reynolds number: 78291.9
PSet_Revit_Identity Data - Mark: 170
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.64 m; Start Offset: 3.64 m; End Offset: 3.64 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.565 m; Top Elevation: 3.715 m; Equivalent Diameter: 0.688942; Size Lock: no; Loss Coefficient: 0.0204316; Hydraulic Diameter: 0.615157; Section: 187; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.162294 m2
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567045
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567045
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 1350x450; Width: 4.42913; Height: 1.47638; Length: 0.378226 m
PSet_Revit_Identity Data - Mark: 171
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.415 m; Top Elevation: 3.865 m; Equivalent Diameter: 2.69666; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 2.21457; Section: 289; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.36161 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.64 m; Start Offset: 3.64 m; End Offset: 3.64 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567047
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567047
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.64 m; Start Offset: 3.64 m; End Offset: 3.64 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 20.5599; Friction: 0.220945; Pressure Drop: 0.22829; Velocity Pressure: 7.19746; Reynolds number: 78291.9
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.565 m; Top Elevation: 3.715 m; Equivalent Diameter: 0.688942; Size Lock: no; Loss Coefficient: 0.0317182; Hydraulic Diameter: 0.615157; Section: 187; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.251947 m2
PSet_Revit_Dimensions - Size: 250x150; Width: 0.82021; Height: 0.492126; Length: 0.314933 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 172
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567050
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567050
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 20.5599; Friction: 0.220945; Pressure Drop: 0.230418; Velocity Pressure: 7.19746; Reynolds number: 78291.9
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.64 m; Start Offset: 3.64 m; End Offset: 3.64 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 173
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.565 m; Top Elevation: 3.715 m; Equivalent Diameter: 0.688942; Size Lock: no; Loss Coefficient: 0.0320137; Hydraulic Diameter: 0.615157; Section: 93; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.254294 m2
PSet_Revit_Dimensions - Size: 250x150; Width: 0.82021; Height: 0.492126; Length: 0.317868 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567051
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567051
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.02231 m; Start Offset: 3.02231 m; End Offset: 3.35893 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0293017; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.336623 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.02231 m; Top Elevation: 3.35893 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0234497; Hydraulic Diameter: 0.984252; Section: 92; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.403948 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 174
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:567057
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:567057
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.64 m; Start Offset: 3.64 m; End Offset: 3.64 m; Slope: 0
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.49 m; Top Elevation: 3.79 m; Equivalent Diameter: 1.96095; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 1.54668; Section: 252; Insulation Thickness: 0; Lining Thickness: 0; Area: 3.26705 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 1100x300; Width: 3.60892; Height: 0.984252; Length: 1.1668 m
PSet_Revit_Identity Data - Mark: 176
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
