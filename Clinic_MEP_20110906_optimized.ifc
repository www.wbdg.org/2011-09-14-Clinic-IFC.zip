Properties of the parts of a building model (IFC2X3), part 51 of 295

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568675
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.124934; Hydraulic Diameter: 0.492126; Section: 443; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.931018 m
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568678
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568678
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.24971 m
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 5.4354; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.167701; Hydraulic Diameter: 0.492126; Section: 447; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 75
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568680
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568680
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Identity Data - Mark: 76
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 3.91944; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.120928; Hydraulic Diameter: 0.492126; Section: 466; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.901164 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568682
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568682
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.831714 m
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 77
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 3.61739; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.111609; Hydraulic Diameter: 0.492126; Section: 464; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568685
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568685
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.943997 m
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 4.10574; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 78
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.126676; Hydraulic Diameter: 0.492126; Section: 453; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568693
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568693
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.122564; Hydraulic Diameter: 0.492126; Section: 455; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.913357 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 3.97248; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Identity Data - Mark: 81
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568696
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568696
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.0978675; Hydraulic Diameter: 0.82021; Section: 416; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.411094; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Identity Data - Mark: 82
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.19051 m
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568698
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568698
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.129011; Hydraulic Diameter: 0.82021; Section: 411; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.56936 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 83
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.541912; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568700
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568700
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Identity Data - Mark: 84
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.112105; Hydraulic Diameter: 0.656168; Section: 398; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.14966; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.10943 m
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568703
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568703
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.147371; Hydraulic Diameter: 0.656168; Section: 396; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 85
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.45842 m
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.51131; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568706
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568706
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.0994787; Hydraulic Diameter: 0.82021; Section: 403; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.417861; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Identity Data - Mark: 86
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.21011 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568709
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568709
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Identity Data - Mark: 87
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.59867 m
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.214527; Hydraulic Diameter: 0.492126; Section: 387; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 6.95311; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568711
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568711
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.187079; Hydraulic Diameter: 0.492126; Section: 377; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Identity Data - Mark: 88
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.39413 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 6.06349; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568714
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568714
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Identity Data - Mark: 91
PSet_Revit_Dimensions - Diameter: 0.984252; Length: 1.17957 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.0825653; Hydraulic Diameter: 0.984252; Section: 347; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 10.9074; Friction: 0.0432181; Pressure Drop: 0.167253; Velocity Pressure: 2.02571; Reynolds number: 66456.3
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568716
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568716
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.22963 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.101084; Hydraulic Diameter: 0.82021; Section: 351; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.424602; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Identity Data - Mark: 92
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568718
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568718
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 93
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Dimensions - Diameter: 1.14829; Length: 1.71663 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.10537; Hydraulic Diameter: 1.14829; Section: 339; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.01359; Friction: 0.0204572; Pressure Drop: 0.115215; Velocity Pressure: 1.09343; Reynolds number: 56962.5
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568720
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568720
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 94
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 5.89053; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.181743; Hydraulic Diameter: 0.492126; Section: 335; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.35436 m
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568722
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568722
PSet_Revit_Identity Data - Mark: 95
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.142426; Hydraulic Diameter: 0.656168; Section: 309; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.40949 m
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.4606; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568724
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568724
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.20017; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.117031; Hydraulic Diameter: 0.656168; Section: 311; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.15818 m
PSet_Revit_Identity Data - Mark: 96
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568726
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568726
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.39584; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Identity Data - Mark: 97
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.347 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.136111; Hydraulic Diameter: 0.656168; Section: 325; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568728
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568728
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.35779 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Identity Data - Mark: 98
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.40703; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.137202; Hydraulic Diameter: 0.656168; Section: 323; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568730
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568730
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.112172; Hydraulic Diameter: 0.656168; Section: 307; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Identity Data - Mark: 99
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.11008 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.15034; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568732
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568732
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.11838 m
PSet_Revit_Identity Data - Mark: 100
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.15894; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.11301; Hydraulic Diameter: 0.656168; Section: 297; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568734
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568734
PSet_Revit_Identity Data - Mark: 101
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.108909; Hydraulic Diameter: 0.656168; Section: 257; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.11688; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.0778 m
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568737
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568737
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.158779; Hydraulic Diameter: 0.656168; Section: 251; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.6283; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.57133 m
PSet_Revit_Identity Data - Mark: 102
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568739
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568739
PSet_Revit_Identity Data - Mark: 107
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.165105; Hydraulic Diameter: 0.656168; Section: 148; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.63393 m
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.69318; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
