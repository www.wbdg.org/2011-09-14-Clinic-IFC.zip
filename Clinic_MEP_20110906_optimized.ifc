Properties of the parts of a building model (IFC2X3), part 5 of 295

# IfcSpace (526)
Name | In | LongName = Name | Area (m2) = GSA BIM Area (m2) | Perimeter (m) | Unbounded Height (m) | Volume (m3) | Level | Upper Limit | Limit Offset (m) | Base Offset (m) | Category Description | Category Code | CirculationZoneName | FireAlarmZoneName | HistoricPreservationZoneName | LightingZoneName | OccupancyZoneName | VentilationZoneName | Number | OmniClass Table 13 Category | RoomTag
1C13-M | Level 1 | COMM. ROOM | 11.0649 | 13.733 | 4 | 44.2597 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C13-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.95122; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C13; Room Name: COMM. ROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2A05-M | Level 2 | OH DTR #1 | 10.511 | 11.3886 | 4 | 42.0441 | Level 2 | Level 2 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A05-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.19533; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2A05; Room Name: OH DTR #1; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2A06-M | Level 2 | OH DTR #2 | 11.0779 | 11.1944 | 4 | 44.3118 | Level 2 | Level 2 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A06-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.84539; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2A06; Room Name: OH DTR #2; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1EC1-M | Level 1 | CORRIDOR | 50.9874 | 64.072 | 4 | 203.95 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1EC1-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 41.4947; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.02551; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1EC1; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B18-M | Level 2 | PH TECH | 8.66001 | 13.0049 | 4 | 34.64 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B18-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.20073; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B18; Room Name: PH TECH; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B8-M | Level 2 | OFFICE / EXAM | 11.7358 | 14.344 | 4 | 46.9432 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B8-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.86066; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B8; Room Name: OFFICE / EXAM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1BC2-M | Level 1 | CORRIDOR | 27.3173 | 35.8309 | 4 | 109.269 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1BC2-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.2894; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1BC2; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C18-M | Level 2 | ELECTRICAL | 9.07666 | 12.064 | 4 | 36.3066 | Level 2 | Level 2 | 4 | 0 | Electrical Room | 13-81 21 21 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C18-M | 13-81 21 21: Electrical Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 0; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C18; Room Name: ELECTRICAL; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1A04-M | Level 1 | TRICARE OFFICE | 8.59024 | 11.73 | 4 | 34.361 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A04-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.54758; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1A04; Room Name: TRICARE OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2A07-M | Level 2 | OH DTR #3 | 11.0043 | 11.5343 | 4 | 44.0172 | Level 2 | Level 2 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A07-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.02595; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2A07; Room Name: OH DTR #3; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1C19-M | Level 1 | AUDIO | 10.4006 | 13.016 | 4 | 41.6026 | Level 1 | Level 1 | 4 | 0 | Equipment Room | 13-81 21 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C19-M | 13-81 21 11: Equipment Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.00076; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C19; Room Name: AUDIO; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1DC7-M | Level 1 | CORRIDOR | 29.8249 | 38.0633 | 4 | 119.3 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1DC7-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.11949; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1DC7; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1AS1-M | Level 1 | STAIR | 13.5765 | 15.398 | 4 | 54.3062 | Level 1 | Level 1 | 4 | 0 | Stairway | 13-85 21 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1AS1-M | 13-85 21 11: Stairway | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 0; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1AS1; Room Name: STAIR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B6-M | Level 2 | STAFF TOILET | 5.01267 | 9.096 | 4 | 20.0507 | Level 2 | Level 2 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B6-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 8.70101; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B6; Room Name: STAFF TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D38-M | Level 1 | TRMT ROOM | 22.1985 | 19.164 | 4 | 88.7941 | Level 1 | Level 1 | 4 | 0 | Treatment Room | 13-41 41 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D38-M | 13-41 41 11: Treatment Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.13953; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D38; Room Name: TRMT ROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B19-M | Level 2 | OFFICE | 8.1407 | 11.608 | 4 | 32.5628 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B19-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.83729; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B19; Room Name: OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E20-M | Level 1 | TRASH | 7.87703 | 11.8592 | 4 | 31.5081 | Level 1 | Level 1 | 4 | 0 | Soiled Storage Room Space | 13-75 41 14 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E20-M | 13-75 41 14: Soiled Storage Room Space | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.21907; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E20; Room Name: TRASH; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2A03-M | Level 2 | SEC. OFFICE | 14.7787 | 15.458 | 4 | 59.1149 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A03-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.01539; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2A03; Room Name: SEC. OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D06-M | Level 2 | COPY / FILE | 11.1552 | 13.524 | 4 | 44.6208 | Level 2 | Level 2 | 4 | 0 | Copy Room | 13-15 11 34 27 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D06-M | 13-15 11 34 27: Copy Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.81322; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D06; Room Name: COPY / FILE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1EC2-M | Level 1 | CORRIDOR | 7.27263 | 11.926 | 4 | 29.0905 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1EC2-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.86307; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1EC2; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D04-M | Level 2 | SYS. ANALYST | 19.4412 | 20.0675 | 4 | 77.7647 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D04-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 24.8968; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.94948; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D04; Room Name: SYS. ANALYST; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2BC5-M | Level 2 | CORRIDOR | 20.9417 | 28.7188 | 4 | 83.7667 | Level 2 | Level 2 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2BC5-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.57572; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2BC5; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2BS2-M | Level 2 | STAIR | 14.3924 | 16.836 | 4 | 57.5694 | Level 2 | Level 2 | 4 | 0 | Stairway | 13-85 21 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2BS2-M | 13-85 21 11: Stairway | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.60913; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2BS2; Room Name: STAIR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B16-M | Level 2 | PH TECH | 8.54177 | 11.718 | 4 | 34.1671 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B16-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.57801; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B16; Room Name: PH TECH; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B02-M | Level 1 | SPECIMEN TOILET | 4.90397 | 9.57795 | 4 | 19.6159 | Level 1 | Level 1 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B02-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 9.36512; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B02; Room Name: SPECIMEN TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D18-M | Level 2 | TECH. OFFICE | 82.0892 | 45.216 | 4 | 328.357 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D18-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 66.3916; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 2.64116; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D18; Room Name: TECH. OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D09-M | Level 2 | ADMIN OFFICE | 13.3152 | 14.806 | 4 | 53.2609 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D09-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.33185; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D09; Room Name: ADMIN OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D07-M | Level 2 | SUPER | 8.49589 | 11.709 | 4 | 33.9835 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D07-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.60845; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D07; Room Name: SUPER; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D14-M | Level 2 | OPS SQUAD CMDR | 12.715 | 14.8738 | 4 | 50.8599 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D14-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.60911; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D14; Room Name: OPS SQUAD CMDR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B04-M | Level 1 | LAB | 51.1951 | 36.096 | 4 | 204.78 | Level 1 | Level 1 | 4 | 0 | Laboratory | 13-15 11 24 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B04-M | 13-15 11 24 11: Laboratory | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 24.8968; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 3.3808; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B04; Room Name: LAB; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D02-M | Level 2 | DATA / ARCHIVE STORAGE | 9.22564 | 12.442 | 4 | 36.9026 | Level 2 | Level 2 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D02-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.46669; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D02; Room Name: DATA / ARCHIVE STORAGE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D15-M | Level 2 | 1ST SGT | 9.9254 | 12.949 | 4 | 39.7016 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D15-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.2557; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D15; Room Name: 1ST SGT; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D19-M | Level 2 | READINESS NCOIC OFFICE | 9.96647 | 12.8889 | 4 | 39.8659 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D19-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.20101; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D19; Room Name: READINESS NCOIC OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D16-M | Level 2 | RMO DIR. | 8.96728 | 12.5509 | 4 | 35.8691 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D16-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.71123; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D16; Room Name: RMO DIR.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D08-M | Level 2 | QA / HRD DIRECTOR | 8.28308 | 11.786 | 4 | 33.1323 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D08-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.82281; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D08; Room Name: QA / HRD DIRECTOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D01-M | Level 2 | PARTS STORAGE | 8.25014 | 11.926 | 4 | 33.0006 | Level 2 | Level 2 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D01-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.93142; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D01; Room Name: PARTS STORAGE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D10-M | Level 2 | SEC. WAIT | 15.6638 | 16.378 | 4 | 62.655 | Level 2 | Level 2 | 4 | 0 | Waiting Room | 13-51 31 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D10-M | 13-51 31 11: Waiting Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.01364; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D10; Room Name: SEC. WAIT; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2R01 | Level 2 | ROOF | 52.8728 | 29.706 | 4 | 203.631 | Level 2 | Level 2 | 4 | 0 | Other General Facility Service Spaces | 13-81 11 99 | Circulation Zone 2R | Fire Alarm Zone 2R | Historic Preservation Zone 2R | Lighting Zone 2R | Occupancy Zone 2R | Ventilation Zone 2R | 2R01 | 13-81 11 99: Other General Facility Service Spaces | RoomTag
1AC4 | Level 1 | CORRIDOR | 9.55147 | 13.7932 | 4.57 | 40.2144 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1AC4 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C07 | Level 2 | M. STAFF TOILET | 18.2427 | 27.3188 | 4.68 | 77.0474 | Level 2 | Roof - Main | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C07 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1ES2 | Level 1 | STAIR | 16.0319 | 18.161 | 4.57 | 67.7732 | Level 1 | Level 2 | 0 | 0 | Stairway | 13-85 21 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1ES2 | 13-85 21 11: Stairway | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B22 | Level 2 | M. TOILET | 5.16718 | 9.11944 | 4.68 | 20.7808 | Level 2 | Roof - Main | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B22 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B21 | Level 2 | PH SUPER | 9.25086 | 12.5366 | 4.68 | 39.4905 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B21 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D06 | Level 2 | COPY / FILE | 11.9777 | 14.02 | 4.68 | 52.2063 | Level 2 | Roof - Main | 0 | 0 | Copy Room | 13-15 11 34 27 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D06 | 13-15 11 34 27: Copy Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2DC2 | Level 2 | CORRIDOR | 30.1132 | 36.3978 | 4.68 | 132.799 | Level 2 | Roof - Main | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2DC2 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2AS1 | Level 2 | STAIR | 14.4483 | 15.3236 | 4.68 | 63.8539 | Level 2 | Roof - Main | 0 | 0 | Stairway | 13-85 21 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2AS1 | 13-85 21 11: Stairway | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D18 | Level 1 | TOILET | 8.26027 | 12.8768 | 4.57 | 33.7603 | Level 1 | Level 2 | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D18 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C08 | Level 2 | W. STAFF TOILET | 15.7322 | 21.984 | 4.68 | 66.7915 | Level 2 | Roof - Main | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C08 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D14 | Level 1 | SPECIMEN TOILET | 4.75347 | 8.736 | 4.57 | 19.1241 | Level 1 | Level 2 | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D14 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D04 | Level 1 | TOILET | 5.10462 | 9.078 | 4.57 | 20.9342 | Level 1 | Level 2 | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D04 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1CC3 | Level 1 | CORRIDOR | 11.4965 | 15.7842 | 4.57 | 48.4793 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1CC3 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D19 | Level 2 | READINESS NCOIC OFFICE | 10.9078 | 13.5279 | 4.68 | 46.6431 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D19 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1A12 | Level 1 | M. TOILET | 9.91049 | 13.184 | 4.57 | 41.8015 | Level 1 | Level 2 | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A12 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B5 | Level 2 | W. TOILET | 4.73083 | 8.976 | 4.68 | 19.3327 | Level 2 | Roof - Main | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B5 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B13 | Level 2 | ELECTRICAL | 9.68587 | 12.977 | 4.68 | 41.6723 | Level 2 | Roof - Main | 0 | 0 | Electrical Room | 13-81 21 21 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B13 | 13-81 21 21: Electrical Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C16 | Level 2 | CERAMIC LAB | 11.155 | 14.018 | 4.68 | 47.4451 | Level 2 | Roof - Main | 0 | 0 | Laboratory | 13-15 11 24 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C16 | 13-15 11 24 11: Laboratory | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B01 | Level 2 | OFFICE | 9.36297 | 12.861 | 4.68 | 40.2377 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B01 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D23 | Level 1 | GROUP IS | 19.1868 | 18.161 | 4.57 | 81.8849 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D23 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B06 | Level 1 | LAB OFFICE | 10.4755 | 13.1609 | 4.57 | 42.7346 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B06 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D22 | Level 1 | TEAM INTERACTION | 24.237 | 20.765 | 4.57 | 106.108 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D22 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1AC2 | Level 1 | CORRIDOR | 19.605 | 24.0652 | 4.57 | 87.28 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1AC2 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C15 | Level 2 | COMM. ROOM | 9.58001 | 12.53 | 4.68 | 41.2928 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C15 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D01 | Level 1 | SL. LIN. / TRASH | 2.00168 | 6.1929 | 4.57 | 7.59687 | Level 1 | Level 2 | 0 | 0 | Soiled Storage Room Space | 13-75 41 14 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D01 | 13-75 41 14: Soiled Storage Room Space | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2BS2 | Level 2 | STAIR | 15.4516 | 17.332 | 4.68 | 67.3562 | Level 2 | Roof - Main | 0 | 0 | Stairway | 13-85 21 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2BS2 | 13-85 21 11: Stairway | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C23 | Level 2 | M. TOILET | 8.65877 | 13.2267 | 4.68 | 35.8677 | Level 2 | Roof - Main | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C23 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1C08 | Level 1 | SCREEN EYE TEST | 9.81776 | 13.352 | 4.57 | 41.5809 | Level 1 | Level 2 | 0 | 0 | Physical Examination Room | 13-41 41 14 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C08 | 13-41 41 14: Physical Examination Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1C04 | Level 1 | FITTING / DISP. | 10.1189 | 12.623 | 4.57 | 42.0014 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C04 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2BC2 | Level 2 | CORRIDOR | 29.512 | 32.1099 | 4.68 | 129.127 | Level 2 | Roof - Main | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2BC2 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B23 | Level 2 | BEE TECH | 10.7975 | 13.226 | 4.68 | 46.3948 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B23 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1DC5 | Level 1 | CORRIDOR | 6.61219 | 10.2786 | 4.57 | 27.7547 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1DC5 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1DC1 | Level 1 | WAITING / ACTIVITY AREA | 182.28 | 77.9501 | 4.57 | 814.452 | Level 1 | Level 2 | 0 | 0 | Waiting Room | 13-51 31 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1DC1 | 13-51 31 11: Waiting Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2DC1 | Level 2 | CORRIDOR | 21.5518 | 26.2857 | 4.68 | 94.273 | Level 2 | Roof - Main | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2DC1 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1A11 | Level 1 | JAN. | 2.03661 | 6.022 | 4.57 | 7.6713 | Level 1 | Level 2 | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A11 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D26 | Level 1 | TOILET | 5.04348 | 9.172 | 4.57 | 20.1593 | Level 1 | Level 2 | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D26 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
