Properties of the parts of a building model (IFC2X3), part 79 of 295

# IfcFlowSegment: Pipe Types:Cold Water:688653
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:688658
In: Level 1
Type - ElementType: Pipe Types:Cold Water:688658
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 3; Insulation Thickness: 0; Invert Elevation: -0.408105 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 66232.2; Relative Roughness: 6381.89; Flow State: 2; Friction Factor: 0.0130723; Velocity: 15.0447; Friction: 786.845; Pressure Drop: 1757.98; Section: 268; Area: 0.0427876 m2
PSet_Revit_Identity Data - Mark: 2116
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.0625; Inner Diameter: 0.0531824; Size: 20 mmø; Diameter: 0.0656168; Length: 0.680986 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:688663
In: Level 1
Type - ElementType: Pipe Types:Cold Water:688663
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: -0.408105 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 6381.89; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 604; Area: 0.0456873 m2
PSet_Revit_Dimensions - Outer Diameter: 0.0625; Inner Diameter: 0.0531824; Size: 20 mmø; Diameter: 0.0656168; Length: 0.727136 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 2117
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:688668
In: Level 1
Type - ElementType: Pipe Types:Cold Water:688668
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.0625; Inner Diameter: 0.0531824; Size: 20 mmø; Diameter: 0.0656168; Length: 2.97228 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: -0.408105 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 6381.89; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 603; Area: 0.186754 m2
PSet_Revit_Identity Data - Mark: 2118
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:688695
In: Level 1
Type - ElementType: Pipe Types:Cold Water:688695
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: -0.382538 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 6381.89; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 604; Area: 0.0734477 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.382538 m; Start Offset: -0.382538 m; End Offset: 0.786419 m
PSet_Revit_Dimensions - Outer Diameter: 0.0625; Inner Diameter: 0.0531824; Size: 20 mmø; Diameter: 0.0656168; Length: 1.16896 m
PSet_Revit_Identity Data - Mark: 2120
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:688706
In: Level 1
Type - ElementType: Pipe Types:Cold Water:688706
PSet_Revit_Identity Data - Mark: 2122
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.0625; Inner Diameter: 0.0531824; Size: 20 mmø; Diameter: 0.0656168; Length: 1.16896 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 3; Insulation Thickness: 0; Invert Elevation: -0.382538 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 66232.2; Relative Roughness: 6381.89; Flow State: 2; Friction Factor: 0.0130723; Velocity: 15.0447; Friction: 786.845; Pressure Drop: 3017.68; Section: 268; Area: 0.0734477 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.382538 m; Start Offset: -0.382538 m; End Offset: 0.786419 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:688727
In: Level 1
Type - ElementType: Pipe Types:Cold Water:688727
PSet_Revit_Identity Data - Mark: 2125
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.331968 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.806263 m; Start Offset: 0.806263 m; End Offset: 0.806263 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 3; Insulation Thickness: 0; Invert Elevation: 0.800933 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 7586.25; Section: 267; Area: 0.0156436 m2
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:688749
In: Level 1
Type - ElementType: Pipe Types:Cold Water:688749
PSet_Revit_Identity Data - Mark: 2127
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.209164 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 0.800933 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 4196.85; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 626; Area: 0.00985662 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.806263 m; Start Offset: 0.806263 m; End Offset: 0.806263 m; Slope: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:688826
In: Level 1
Type - ElementType: Pipe Types:Cold Water:688826
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: -0.408105 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 6381.89; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 601; Area: 0.0214584 m2
PSet_Revit_Dimensions - Outer Diameter: 0.0625; Inner Diameter: 0.0531824; Size: 20 mmø; Diameter: 0.0656168; Length: 0.341522 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 2128
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:688847
In: Level 1
Type - ElementType: Pipe Types:Cold Water:688847
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: -0.40533 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 53599.1; Section: 119; Area: 0.110527 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Identity Data - Mark: 2129
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 2.34545 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:688854
In: Level 1
Type - ElementType: Pipe Types:Cold Water:688854
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 2130
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: -0.44877 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 38401.6; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 551; Area: 0.627145 m2
PSet_Revit_Dimensions - Outer Diameter: 0.333333; Inner Diameter: 0.320013; Size: 100 mmø; Diameter: 0.328084; Length: 1.99627 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:688858
In: Level 1
Type - ElementType: Pipe Types:Cold Water:688858
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: -0.40533 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 21746.3; Section: 119; Area: 0.0448431 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.951601 m
PSet_Revit_Identity Data - Mark: 2131
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:688917
In: Level 1
Type - ElementType: Pipe Types:Cold Water:688917
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: -0.385713 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 26912.9; Section: 119; Area: 0.0554972 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.385713 m; Start Offset: -0.385713 m; End Offset: 0.791975 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 2133
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 1.17769 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:688958
In: Level 1
Type - ElementType: Pipe Types:Cold Water:688958
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.84595 m; Start Offset: 0.84595 m; End Offset: 0.82055 m
PSet_Revit_Identity Data - Mark: 2134
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 0.82055 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 580.45; Section: 119; Area: 0.00119695 m2
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.0254 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:688959
In: Level 1
Type - ElementType: Pipe Types:Cold Water:688959
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 0.800933 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 1588.81; Section: 119; Area: 0.00327629 m2
PSet_Revit_Identity Data - Mark: 2135
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.069525 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.806263 m; Start Offset: 0.806263 m; End Offset: 0.806263 m; Slope: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:688962
In: Level 1
Type - ElementType: Pipe Types:Cold Water:688962
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.322801 m
PSet_Revit_Identity Data - Mark: 2136
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 0.800933 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 7376.78; Section: 119; Area: 0.0152117 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.806263 m; Start Offset: 0.806263 m; End Offset: 0.806263 m; Slope: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:688997
In: Level 1
Type - ElementType: Pipe Types:Cold Water:688997
PSet_Revit_Identity Data - Mark: 2137
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.863994 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: -0.40533 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 19744.3; Section: 121; Area: 0.0407148 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:689014
In: Level 1
Type - ElementType: Pipe Types:Cold Water:689014
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 1.37395 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 11.5; Insulation Thickness: 0; Invert Elevation: -0.41742 m; Additional Flow: 0; Flow: 0.0628299; Reynolds Number: 57933.8; Relative Roughness: 13716.5; Flow State: 2; Friction Factor: 0.0112912; Velocity: 6.1228; Friction: 52.3741; Pressure Drop: 236.087; Section: 113; Area: 0.172655 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 2138
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:689021
In: Level 1
Type - ElementType: Pipe Types:Cold Water:689021
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: -0.44877 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 38401.6; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 550; Area: 0.785058 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.333333; Inner Diameter: 0.320013; Size: 100 mmø; Diameter: 0.328084; Length: 2.49892 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 2139
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:689025
In: Level 1
Type - ElementType: Pipe Types:Cold Water:689025
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 1.20603 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 11.5; Insulation Thickness: 0; Invert Elevation: -0.41742 m; Additional Flow: 0; Flow: 0.0628299; Reynolds Number: 57933.8; Relative Roughness: 13716.5; Flow State: 2; Friction Factor: 0.0112912; Velocity: 6.1228; Friction: 52.3741; Pressure Drop: 207.233; Section: 113; Area: 0.151554 m2
PSet_Revit_Identity Data - Mark: 2140
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:689098
In: Level 1
Type - ElementType: Pipe Types:Cold Water:689098
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.0833333; Inner Diameter: 0.0740157; Size: 25 mmø; Diameter: 0.082021; Length: 0.155628 m
PSet_Revit_Identity Data - Mark: 2143
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.688244 m; Start Offset: 0.688244 m; End Offset: 0.688244 m; Slope: 0
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 10; Insulation Thickness: 0; Invert Elevation: 0.676964 m; Additional Flow: 0; Flow: 0.0601563; Reynolds Number: 85661.5; Relative Roughness: 8881.89; Flow State: 2; Friction Factor: 0.0122545; Velocity: 13.9811; Friction: 457.719; Pressure Drop: 233.707; Section: 111; Area: 0.012223 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:689099
In: Level 1
Type - ElementType: Pipe Types:Cold Water:689099
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 10; Insulation Thickness: 0; Invert Elevation: 0.676964 m; Additional Flow: 0; Flow: 0.0601563; Reynolds Number: 85661.5; Relative Roughness: 8881.89; Flow State: 2; Friction Factor: 0.0122545; Velocity: 13.9811; Friction: 457.719; Pressure Drop: 384.862; Section: 111; Area: 0.0201285 m2
PSet_Revit_Identity Data - Mark: 2144
PSet_Revit_Dimensions - Outer Diameter: 0.0833333; Inner Diameter: 0.0740157; Size: 25 mmø; Diameter: 0.082021; Length: 0.256284 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.688244 m; Start Offset: 0.688244 m; End Offset: 0.688244 m; Slope: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:689121
In: Level 1
Type - ElementType: Pipe Types:Cold Water:689121
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.5 m; Start Offset: 0.5 m; End Offset: 0.5 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.18579 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 0.49467 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 4245.74; Section: 117; Area: 0.00875515 m2
PSet_Revit_Identity Data - Mark: 2145
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:689134
In: Level 1
Type - ElementType: Pipe Types:Cold Water:689134
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 0.514287 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 7579.27; Section: 117; Area: 0.0156292 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.84595 m; Start Offset: 0.84595 m; End Offset: 0.514287 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.331663 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 2146
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:689137
In: Level 1
Type - ElementType: Pipe Types:Cold Water:689137
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.5 m; Start Offset: 0.5 m; End Offset: 0.5 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.795297 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 2147
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 0.49467 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 18174.4; Section: 117; Area: 0.0374775 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:689183
In: Level 1
