Properties of the parts of a building model (IFC2X3), part 171 of 295

# IfcFlowSegment: Pipe Types:Hot Water:719522
PSet_Revit_Mechanical - System Type: Domestic Hot Water; System Name: Domestic Hot Water 1; Fixture Units: 3; Insulation Thickness: 0; Invert Elevation: 3.11467 m; Additional Flow: 0; Flow: 0.0144821; Reynolds Number: 103281; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 15.075; Friction: 1287.39; Pressure Drop: 1702.55; Section: 291; Area: 0.0189952 m2
PSet_Revit_Identity Data - Mark: 3492
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.45 m; Start Offset: -1.45 m; End Offset: -1.45 m; Slope: 0
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Hot Water:719651
In: Level 2
Type - ElementType: Pipe Types:Hot Water:719651
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.982056 m
PSet_Revit_Identity Data - Mark: 3494
PSet_Revit_Mechanical - System Type: Domestic Hot Water; System Name: Domestic Hot Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 3.16467 m; Additional Flow: 0; Flow: 0.00891204; Reynolds Number: 63557.3; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 9.2769; Friction: 487.533; Pressure Drop: 1570.82; Section: 150; Area: 0.0462783 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.4 m; Start Offset: -1.4 m; End Offset: -1.4 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Hot Water:719658
In: Level 2
Type - ElementType: Pipe Types:Hot Water:719658
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 1.95887 m
PSet_Revit_Mechanical - System Type: Domestic Hot Water; System Name: Domestic Hot Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 3.15258 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 13716.5; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 484; Area: 0.246159 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 3495
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.4 m; Start Offset: -1.4 m; End Offset: -1.4 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Hot Water:719662
In: Level 2
Type - ElementType: Pipe Types:Hot Water:719662
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Domestic Hot Water; System Name: Domestic Hot Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 4.76467 m; Additional Flow: 0; Flow: 0.00891204; Reynolds Number: 63557.3; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 9.2769; Friction: 487.533; Pressure Drop: 52.8899; Section: 150; Area: 0.0015582 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 0.2 m; Start Offset: 0.2 m; End Offset: 0.2 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.0330661 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 3496
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Hot Water:719713
In: Level 2
Type - ElementType: Pipe Types:Hot Water:719713
PSet_Revit_Mechanical - System Type: Domestic Hot Water; System Name: Domestic Hot Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 3.18429 m; Additional Flow: 0; Flow: 0.00891204; Reynolds Number: 63557.3; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 9.2769; Friction: 487.533; Pressure Drop: 2513.52; Section: 150; Area: 0.0740517 m2
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 1.57143 m
PSet_Revit_Identity Data - Mark: 3497
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.38571 m; Start Offset: -1.38571 m; End Offset: 0.185713 m
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Hot Water:719717
In: Level 2
Type - ElementType: Pipe Types:Hot Water:719717
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Domestic Hot Water; System Name: Domestic Hot Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 4.76467 m; Additional Flow: 0; Flow: 0.00891204; Reynolds Number: 63557.3; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 9.2769; Friction: 487.533; Pressure Drop: 156.887; Section: 150; Area: 0.00462208 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 0.2 m; Start Offset: 0.2 m; End Offset: 0.2 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.0980836 m
PSet_Revit_Identity Data - Mark: 3498
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Hot Water:719723
In: Level 2
Type - ElementType: Pipe Types:Hot Water:719723
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.631663 m
PSet_Revit_Mechanical - System Type: Domestic Hot Water; System Name: Domestic Hot Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 4.78429 m; Additional Flow: 0; Flow: 0.00891204; Reynolds Number: 63557.3; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 9.2769; Friction: 487.533; Pressure Drop: 1010.36; Section: 150; Area: 0.0297664 m2
PSet_Revit_Identity Data - Mark: 3499
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 0.84595 m; Start Offset: 0.84595 m; End Offset: 0.214287 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1066972
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1066972
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.6 m; Start Offset: -0.6 m; End Offset: -0.6 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: -0.677026 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 0.443594 m2
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 0.941335 m
PSet_Revit_Identity Data - Mark: 5023
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1066978
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1066978
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.6 m; Start Offset: -0.6 m; End Offset: -0.6 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 2.48593 m
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: -0.677026 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 1.17147 m2
PSet_Revit_Identity Data - Mark: 5024
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1067026
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1067026
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.6 m; Start Offset: -0.6 m; End Offset: -0.6 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: -0.677026 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 4.39747 m2
PSet_Revit_Identity Data - Mark: 5025
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 9.33173 m
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1067037
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1067037
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: -0.677026 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 4.96296 m2
PSet_Revit_Identity Data - Mark: 5026
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.6 m; Start Offset: -0.6 m; End Offset: -0.6 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 10.5317 m
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1067042
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1067042
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: -0.677026 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 3.45499 m2
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 7.33173 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.6 m; Start Offset: -0.6 m; End Offset: -0.6 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 5027
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1067082
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1067082
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: -0.515863 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 1.57004 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -5.08586 m; Start Offset: -5.08586 m; End Offset: -1.75414 m
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 3.33173 m
PSet_Revit_Identity Data - Mark: 5029
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1067342
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1067342
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.287 m; Start Offset: 0.287 m; End Offset: 0.287 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 5030
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 3.95407 m
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: 0.209974 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 1.86331 m2
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1067464
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1067464
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 5032
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.202862 m; Start Offset: 0.202862 m; End Offset: -0.515863 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 0.718725 m
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: -0.515863 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 0.338691 m2
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1067529
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1067529
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 3.97586 m
PSet_Revit_Identity Data - Mark: 5033
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.571 m; Start Offset: 0.571 m; End Offset: 0.571 m; Slope: 0
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: 0.493974 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 1.87358 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1067591
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1067591
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.486862 m; Start Offset: 0.486862 m; End Offset: -0.515863 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 1.00272 m
PSet_Revit_Identity Data - Mark: 5036
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: -0.515863 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 0.472523 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1067595
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1067595
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 0.711725 m
PSet_Revit_Identity Data - Mark: 5037
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: -0.677026 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 0.335393 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.6 m; Start Offset: -0.6 m; End Offset: -0.6 m; Slope: 0
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1067834
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1067834
PSet_Revit_Identity Data - Mark: 5038
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.6 m; Start Offset: -0.6 m; End Offset: -0.6 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 1.13173 m
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: -0.677026 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 0.533313 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1067841
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1067841
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 0.286874 m
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: -0.677026 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 0.135186 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 5039
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.6 m; Start Offset: -0.6 m; End Offset: -0.6 m; Slope: 0
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1067931
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1067931
PSet_Revit_Identity Data - Mark: 5040
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.67 m; Start Offset: -1.67 m; End Offset: -1.67 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 0.384295 m
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: 2.82297 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 0.181095 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1067943
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1067943
PSet_Revit_Identity Data - Mark: 5041
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.67 m; Start Offset: -1.67 m; End Offset: -1.67 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: 2.82297 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 0.486189 m2
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 1.03173 m
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1067948
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1067948
PSet_Revit_Identity Data - Mark: 5042
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 2.53173 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.67 m; Start Offset: -1.67 m; End Offset: -1.67 m; Slope: 0
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: 2.82297 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 1.19305 m2
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068026
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1068026
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 5.50173 m
PSet_Revit_Identity Data - Mark: 5044
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: 2.98414 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 2.59263 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.58586 m; Start Offset: -1.58586 m; End Offset: 3.91586 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068030
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1068030
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 9.28996 m
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: 8.51887 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 2236.67; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 5; Area: 2.91853 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 5045
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 4 m; Start Offset: 4 m; End Offset: 4 m; Slope: 0
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068090
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1068090
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 5046
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 0.574973 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 4 m; Start Offset: 4 m; End Offset: 4 m; Slope: 0
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: 8.51887 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 2236.67; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 5; Area: 0.180633 m2
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068207
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1068207
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 4 m; Start Offset: 4 m; End Offset: 4 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 5051
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 1.51008 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: 8.51887 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 2236.67; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 1; Area: 0.474405 m2
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068250
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1068250
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: 4.66684 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 2236.67; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 1; Area: 1.20776 m2
PSet_Revit_Identity Data - Mark: 5052
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.94126 m; Start Offset: 3.94126 m; End Offset: 0.0968375 m
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 3.84443 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068358
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1068358
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 4 m; Start Offset: 4 m; End Offset: 4 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 4.11948 m
PSet_Revit_Identity Data - Mark: 5056
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: 8.49297 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 1.94126 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068496
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1068496
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.571 m; Start Offset: 0.571 m; End Offset: 0.571 m; Slope: 0
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: 0.493974 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 0.0735872 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 5058
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 0.156157 m
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068583
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1068583
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: -0.677026 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 1.14592 m2
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 2.43173 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 5059
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.6 m; Start Offset: -0.6 m; End Offset: -0.6 m; Slope: 0
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068590
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1068590
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.6 m; Start Offset: -0.6 m; End Offset: -0.6 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: -0.677026 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 4.41632 m2
PSet_Revit_Identity Data - Mark: 5060
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 9.37173 m
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068608
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1068608
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: -0.677026 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 5.03618 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 5062
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 10.6871 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.6 m; Start Offset: -0.6 m; End Offset: -0.6 m; Slope: 0
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068612
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1068612
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.6 m; Start Offset: -0.6 m; End Offset: -0.6 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 7.33173 m
PSet_Revit_Identity Data - Mark: 5063
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: -0.677026 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 3.45499 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068623
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1068623
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.6 m; Start Offset: -0.6 m; End Offset: -0.6 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: -0.677026 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 0.486189 m2
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 1.03173 m
PSet_Revit_Identity Data - Mark: 5064
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
