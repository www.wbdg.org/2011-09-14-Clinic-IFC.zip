Properties of the parts of a building model (IFC2X3), part 7 of 295

# IfcSpace (526)
Name | In | LongName = Name | Area (m2) = GSA BIM Area (m2) | Perimeter (m) | Unbounded Height (m) | Volume (m3) | Level | Upper Limit | Limit Offset (m) | Base Offset (m) | Category Description | Category Code | CirculationZoneName | FireAlarmZoneName | HistoricPreservationZoneName | LightingZoneName | OccupancyZoneName | VentilationZoneName | Number | OmniClass Table 13 Category | RoomTag
2C10 | Level 2 | DIPC DECON | 11.0309 | 13.492 | 4.68 | 47.9695 | Level 2 | Roof - Main | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C10 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2CS3 | Level 2 | STAIR | 15.2659 | 17.368 | 4.68 | 66.4769 | Level 2 | Roof - Main | 0 | 0 | Stairway | 13-85 21 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2CS3 | 13-85 21 11: Stairway | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D20 | Level 1 | APPMTS | 11.7909 | 13.74 | 4.57 | 50.0618 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D20 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1C01 | Level 1 | WAITING | 11.8597 | 13.5102 | 4.57 | 53.1793 | Level 1 | Level 2 | 0 | 0 | Waiting Room | 13-51 31 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C01 | 13-51 31 11: Waiting Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1BC1 | Level 1 | CORRIDOR | 5.69274 | 9.876 | 4.57 | 23.2878 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1BC1 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
3R03 | Roof - Main | ROOF | 98.2566 | 42.4089 | 6.48688 | 637.378 | Roof - Main | Roof - Main | 4 | -2.48688 | Other General Facility Service Spaces | 13-81 11 99 | Circulation Zone 3R | Fire Alarm Zone 3R | Historic Preservation Zone 3R | Lighting Zone 3R | Occupancy Zone 3R | Ventilation Zone 3R | 3R03 | 13-81 11 99: Other General Facility Service Spaces | RoomTag
1A13 | Level 1 | STAFF TOILET | 4.4685 | 8.506 | 4.57 | 17.9939 | Level 1 | Level 2 | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A13 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2BC6 | Level 2 | CORRIDOR | 8.57508 | 12.7244 | 4.68 | 37.2922 | Level 2 | Roof - Main | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2BC6 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D11 | Level 1 | INTERACTION STATION | 12.698 | 14.779 | 4.57 | 54.2672 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D11 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B02 | Level 1 | SPECIMEN TOILET | 5.54853 | 10.2769 | 4.57 | 22.4111 | Level 1 | Level 2 | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B02 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D17 | Level 1 | JAN. CL. | 2.05671 | 5.8058 | 4.57 | 7.63765 | Level 1 | Level 2 | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D17 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1BC4 | Level 1 | CORRIDOR | 44.3648 | 44.8858 | 4.57 | 190.667 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1BC4 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D12 | Level 2 | VEST. | 2.79678 | 6.5021 | 4.68 | 10.89 | Level 2 | Roof - Main | 0 | 0 | Entry Vestibule | 13-85 31 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D12 | 13-85 31 11: Entry Vestibule | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C04 | Level 2 | GEN. DENT. DTR #7 | 11.1795 | 11.9485 | 4.68 | 48.3108 | Level 2 | Roof - Main | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C04 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C14 | Level 2 | GEN. DENT. DTR #10 | 12.0102 | 13.997 | 4.68 | 51.6858 | Level 2 | Roof - Main | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C14 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1EC4 | Level 1 | CORRIDOR | 9.30567 | 12.6514 | 4.57 | 38.6777 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1EC4 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2A12-A | Level 2 | X-RAY ALCOVE | 2.28699 | 5.62774 | 4.68 | 9.33931 | Level 2 | Roof - Main | 0 | 0 | Scanning/Imaging Room | 13-41 41 31 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A12-A | 13-41 41 31: Scanning/Imaging Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2A07 | Level 2 | OH DTR #3 | 12.0034 | 11.3865 | 4.68 | 51.5002 | Level 2 | Roof - Main | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A07 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B10 | Level 2 | RECEPTION | 15.1738 | 16.625 | 4.68 | 66.3692 | Level 2 | Roof - Main | 0 | 0 | Reception Space | 13-11 11 31 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B10 | 13-11 11 31: Reception Space | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B8 | Level 2 | OFFICE / EXAM | 12.6405 | 14.84 | 4.68 | 54.9235 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B8 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2CC3 | Level 2 | CORRIDOR | 17.2506 | 17.0827 | 4.68 | 75.2743 | Level 2 | Roof - Main | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2CC3 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B01 | Level 1 | RECEPTION | 9.47555 | 12.664 | 4.57 | 40.2539 | Level 1 | Level 2 | 0 | 0 | Reception Space | 13-11 11 31 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B01 | 13-11 11 31: Reception Space | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B14 | Level 2 | RECS / FORMS STORAGE | 10.5466 | 13.604 | 4.68 | 45.661 | Level 2 | Roof - Main | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B14 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1C18 | Level 1 | PHYSICAL EXAM | 58.0301 | 41.077 | 4.57 | 253.075 | Level 1 | Level 2 | 0 | 0 | Physical Examination Room | 13-41 41 14 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C18 | 13-41 41 14: Physical Examination Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D11 | Level 2 | CMDR OFFICE | 15.8554 | 16.0179 | 4.68 | 67.7917 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D11 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1CC1 | Level 1 | CORRIDOR | 42.6545 | 49.386 | 4.57 | 183.872 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1CC1 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D16 | Level 2 | RMO DIR. | 9.75054 | 13.1899 | 4.68 | 41.9669 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D16 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C17 | Level 2 | PROSTH. LAB | 30.5599 | 25.496 | 4.68 | 133.781 | Level 2 | Roof - Main | 0 | 0 | Laboratory | 13-15 11 24 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C17 | 13-15 11 24 11: Laboratory | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E27 | Level 1 | BENCHSTOCK STORAGE | 9.51258 | 11.3616 | 4.57 | 39.0813 | Level 1 | Level 2 | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E27 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E01 | Level 1 | HK EQUIP. STORAGE | 9.72524 | 12.492 | 4.57 | 40.9751 | Level 1 | Level 2 | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E01 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D05 | Level 1 | TRMT RM. DIRTY PROC. | 14.1331 | 15.0667 | 4.57 | 61.3812 | Level 1 | Level 2 | 0 | 0 | Treatment Room | 13-41 41 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D05 | 13-41 41 11: Treatment Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D06 | Level 1 | SCOPE WASH / DECON. | 8.99752 | 12.507 | 4.57 | 38.0019 | Level 1 | Level 2 | 0 | 0 | Other Grooming Spaces | 13-41 11 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D06 | 13-41 11 99: Other Grooming Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1C17 | Level 1 | CHIEF AERO MED. | 9.94224 | 12.691 | 4.57 | 41.1247 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C17 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B13 | Level 1 | RECEPTION | 22.5898 | 21.5613 | 4.57 | 98.0739 | Level 1 | Level 2 | 0 | 0 | Reception Space | 13-11 11 31 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B13 | 13-11 11 31: Reception Space | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1DC6 | Level 1 | CORRIDOR | 15.0065 | 20.1568 | 4.57 | 63.4585 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1DC6 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E28 | Level 1 | FAC. MGR. OFFICE | 9.73829 | 11.737 | 4.57 | 39.4295 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E28 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E22 | Level 1 | SEC. STORAGE | 6.27284 | 10.424 | 4.57 | 25.7836 | Level 1 | Level 2 | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E22 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1A09 | Level 1 | W. TOILET | 10.8536 | 13.3715 | 4.57 | 44.8673 | Level 1 | Level 2 | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A09 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B16 | Level 2 | PH TECH | 9.51632 | 12.357 | 4.68 | 39.9755 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B16 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D09 | Level 1 | INTERACTION STATION | 12.7792 | 14.3048 | 4.57 | 54.5951 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D09 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2AC5 | Level 2 | CORRIDOR | 9.10214 | 13.0124 | 4.68 | 39.2217 | Level 2 | Roof - Main | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2AC5 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B19 | Level 2 | OFFICE | 8.87578 | 12.104 | 4.68 | 38.0985 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B19 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C19 | Level 2 | CENTRAL ISSUE | 21.0386 | 19.886 | 4.68 | 92.6739 | Level 2 | Roof - Main | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C19 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E11 | Level 1 | STAFF LOUNGE | 14.5917 | 15.28 | 4.57 | 62.425 | Level 1 | Level 2 | 0 | 0 | Break Room | 13-51 11 21 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E11 | 13-51 11 21: Break Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1DC3 | Level 1 | CORRIDOR | 31.8109 | 38.1194 | 4.57 | 135.522 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1DC3 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B15 | Level 2 | WAIT / ERGOM | 9.11758 | 12.24 | 4.68 | 39.1907 | Level 2 | Roof - Main | 0 | 0 | Waiting Room | 13-51 31 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B15 | 13-51 31 11: Waiting Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1A14 | Level 1 | SUPER / NCOIC | 7.22988 | 10.1474 | 4.57 | 30.8391 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A14 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1DC7 | Level 1 | CORRIDOR | 31.9069 | 37.8435 | 4.57 | 136.3 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1DC7 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C06 | Level 2 | GEN. DENT. DTR #8 | 12.0034 | 11.9485 | 4.68 | 51.1267 | Level 2 | Roof - Main | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C06 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E23 | Level 1 | BEE EQUIP. STORAGE | 8.77894 | 12.981 | 4.57 | 36.8106 | Level 1 | Level 2 | 0 | 0 | Equipment Room | 13-81 21 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E23 | 13-81 21 11: Equipment Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E20 | Level 1 | TRASH | 8.95436 | 12.2559 | 4.57 | 35.998 | Level 1 | Level 2 | 0 | 0 | Soiled Storage Room Space | 13-75 41 14 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E20 | 13-75 41 14: Soiled Storage Room Space | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E08 | Level 1 | SUPER | 9.86423 | 13.058 | 4.57 | 41.5923 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E08 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D07 | Level 2 | SUPER | 9.21541 | 12.135 | 4.68 | 39.7607 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D07 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D19 | Level 1 | MDIS VIEW | 5.63662 | 9.711 | 4.57 | 23.3793 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D19 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E16 | Level 1 | BMET WORK STATION | 49.5978 | 27.7751 | 4.57 | 216.612 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E16 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B18 | Level 2 | PH TECH | 9.52429 | 13.8569 | 4.68 | 40.5288 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B18 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2BC1 | Level 2 | CORRIDOR | 12.8241 | 15.4512 | 4.68 | 56.8647 | Level 2 | Roof - Main | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2BC1 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D09 | Level 2 | ADMIN OFFICE | 14.3932 | 15.445 | 4.68 | 62.3152 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D09 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2A06 | Level 2 | OH DTR #2 | 12.0879 | 11.5854 | 4.68 | 51.8448 | Level 2 | Roof - Main | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A06 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D13 | Level 2 | TOILET | 4.74366 | 9.012 | 4.68 | 19.5769 | Level 2 | Roof - Main | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D13 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D17 | Level 2 | CREDENTIALS MGR | 9.64538 | 12.7579 | 4.68 | 40.7054 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D17 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D01 | Level 2 | PARTS STORAGE | 8.92422 | 12.352 | 4.68 | 38.6107 | Level 2 | Roof - Main | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D01 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2R02 | Level 2 | ROOF | 589.756 | 194.084 | 4 | 2314.97 | Level 2 | Level 2 | 4 | 0 | Other General Facility Service Spaces | 13-81 11 99 | Circulation Zone 2R | Fire Alarm Zone 2R | Historic Preservation Zone 2R | Lighting Zone 2R | Occupancy Zone 2R | Ventilation Zone 2R | 2R02 | 13-81 11 99: Other General Facility Service Spaces | RoomTag
1DC4 | Level 1 | CORRIDOR | 15.0608 | 20.1242 | 4.57 | 64.4377 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1DC4 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2BC3 | Level 2 | CORRIDOR | 26.8 | 32.8839 | 4.68 | 116.64 | Level 2 | Roof - Main | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2BC3 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1AC5 | Level 1 | CORRIDOR | 20.3751 | 32.975 | 4.57 | 87.8317 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1AC5 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2CC5 | Level 2 | CORRIDOR | 8.1288 | 12.632 | 4.68 | 34.7149 | Level 2 | Roof - Main | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2CC5 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1A07 | Level 1 | TRICARE OFFICE | 8.73012 | 12.5275 | 4.57 | 36.4201 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A07 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B4 | Level 2 | PSYCH TEST | 9.8406 | 12.61 | 4.68 | 42.9119 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B4 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B17 | Level 2 | CL. UTL. / KITCHENET | 8.99668 | 12.172 | 4.68 | 38.6446 | Level 2 | Roof - Main | 0 | 0 | Kitchen | 13-11 19 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B17 | 13-11 19 11 11: Kitchen | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2AC1 | Level 2 | CORRIDOR | 39.5583 | 30.3806 | 4.68 | 182.007 | Level 2 | Roof - Main | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2AC1 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D30 | Level 1 | WTS & MEAS. ROOM | 9.26534 | 12.672 | 4.57 | 38.8224 | Level 1 | Level 2 | 0 | 0 | Physical Examination Room | 13-41 41 14 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D30 | 13-41 41 14: Physical Examination Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2CC4 | Level 2 | CORRIDOR | 10.846 | 14.568 | 4.68 | 47.0298 | Level 2 | Roof - Main | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2CC4 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1A15 | Level 1 | COUNSELING | 6.39843 | 10.157 | 4.57 | 26.8169 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A15 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1C19 | Level 1 | AUDIO | 11.6268 | 13.798 | 4.57 | 47.5309 | Level 1 | Level 2 | 0 | 0 | Equipment Room | 13-81 21 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C19 | 13-81 21 11: Equipment Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E04 | Level 1 | HK BREAK ROOM | 9.73544 | 12.492 | 4.57 | 41.0217 | Level 1 | Level 2 | 0 | 0 | Break Room | 13-51 11 21 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E04 | 13-51 11 21: Break Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D33 | Level 1 | PEDIATRIC WAITING | 12.7423 | 14.432 | 4.57 | 54.3034 | Level 1 | Level 2 | 0 | 0 | Waiting Room | 13-51 31 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D33 | 13-51 31 11: Waiting Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2A12 | Level 2 | X-RAY | 11.2172 | 14.3622 | 4.68 | 48.4044 | Level 2 | Roof - Main | 0 | 0 | Scanning/Imaging Room | 13-41 41 31 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A12 | 13-41 41 31: Scanning/Imaging Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E05 | Level 1 | CHIEF LOG OFFICE | 9.93876 | 12.628 | 4.57 | 41.9124 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E05 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D34 | Level 1 | INTERACTION STATION | 12.8258 | 14.432 | 4.57 | 54.5951 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D34 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1BC2 | Level 1 | CORRIDOR | 29.4368 | 36.1589 | 4.57 | 124.84 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1BC2 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D08 | Level 1 | INTERACTION STATION | 12.8273 | 14.4329 | 4.57 | 54.6014 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D08 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C12 | Level 2 | DIPC CLEAN | 14.3677 | 18.173 | 4.68 | 62.0415 | Level 2 | Roof - Main | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C12 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D08 | Level 2 | QA / HRD DIRECTOR | 8.98396 | 12.282 | 4.68 | 38.7648 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D08 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D02 | Level 2 | DATA / ARCHIVE STORAGE | 9.92268 | 12.868 | 4.68 | 43.176 | Level 2 | Roof - Main | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D02 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2A08 | Level 2 | GEN. DENT. DTR #4 | 11.7457 | 11.3865 | 4.68 | 50.6922 | Level 2 | Roof - Main | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A08 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D03 | Level 2 | DIR. INFO MGR | 9.4116 | 12.5175 | 4.68 | 40.827 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D03 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B7 | Level 2 | TECH OFFICE | 9.9308 | 12.685 | 4.68 | 43.2279 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B7 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D21 | Level 1 | GROUP IS | 19.1917 | 18.161 | 4.57 | 81.906 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D21 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1A03 | Level 1 | TRICARE OFFICE | 8.87366 | 11.957 | 4.57 | 37.2844 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A03 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D36 | Level 1 | INTERACTION STATION | 12.7053 | 14.432 | 4.57 | 54.1702 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D36 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1C16 | Level 1 | ECG TEST | 10.0079 | 13.668 | 4.57 | 41.2963 | Level 1 | Level 2 | 0 | 0 | Scanning/Imaging Room | 13-41 41 31 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C16 | 13-41 41 31: Scanning/Imaging Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B08 | Level 1 | CENT. STO. | 9.76711 | 12.796 | 4.57 | 40.8399 | Level 1 | Level 2 | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B08 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2A10 | Level 2 | DENTAL WAITING | 7.85686 | 10.8741 | 4.68 | 34.187 | Level 2 | Roof - Main | 0 | 0 | Waiting Room | 13-51 31 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A10 | 13-51 31 11: Waiting Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C22 | Level 2 | LOUNGE | 11.1646 | 13.8043 | 4.68 | 48.3167 | Level 2 | Roof - Main | 0 | 0 | Break Room | 13-51 11 21 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C22 | 13-51 11 21: Break Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D24 | Level 1 | RECORDS | 11.7777 | 13.705 | 4.57 | 50.0618 | Level 1 | Level 2 | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D24 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D35 | Level 1 | INTERACTION STATION | 12.8258 | 14.432 | 4.57 | 54.5951 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D35 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1A04 | Level 1 | TRICARE OFFICE | 9.54452 | 12.369 | 4.57 | 39.2574 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A04 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1C14 | Level 1 | HIST. / INTV. | 8.18416 | 11.509 | 4.57 | 33.4117 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C14 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D02 | Level 1 | INTERACTION STATION | 11.5298 | 13.802 | 4.57 | 48.9939 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D02 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2A01 | Level 2 | LIBRARY / CONF. ROOM | 26.331 | 21.7164 | 4.68 | 116.652 | Level 2 | Roof - Main | 0 | 0 | Conference Room | 13-11 21 17 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A01 | 13-11 21 17: Conference Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D15 | Level 1 | WTS & MEAS. ROOM | 5.06769 | 9.0729 | 4.57 | 20.9182 | Level 1 | Level 2 | 0 | 0 | Physical Examination Room | 13-41 41 14 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D15 | 13-41 41 14: Physical Examination Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D27 | Level 1 | ADMIN WORK STATN. | 10.7499 | 13.412 | 4.57 | 45.5095 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D27 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B24 | Level 2 | BEE TECH | 9.77601 | 12.67 | 4.68 | 41.2986 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B24 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1C15 | Level 1 | PES ADMIN. OFFICE | 15.3931 | 15.77 | 4.57 | 66.6214 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C15 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2A02 | Level 2 | SUPER OFFICE | 10.8708 | 14.101 | 4.68 | 46.9093 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A02 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D10 | Level 1 | INTERACTION STATION | 12.7437 | 14.4329 | 4.57 | 54.3093 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D10 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
