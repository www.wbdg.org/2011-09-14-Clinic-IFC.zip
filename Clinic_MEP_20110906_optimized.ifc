Properties of the parts of a building model (IFC2X3), part 32 of 295

# IfcFlowFitting: Standard (800)
Name | In | Level | Host | Offset (m) | Lining Width = Insulation Width | Lining Height = Insulation Height | Size | System Type | System Name | Mark | Takeoff Fixed Length | Takeoff Length Projection | Takeoff Length
M_Oval to Round Transition - Length:Standard:Standard:567289 | 1BC2 | Level 1 | Level : Level 1 | 3.69003 | 2.62467 | 1.64042 | 800/500-500ø | Supply Air | Mechanical Supply Air 1 | 1559 | PSet_Revit_Dimensions - Duct Width: 2.62467; Duct Height: 1.64042; Duct Length: 0.984252; OffsetHeight: 0.82021; OffsetWidth: 1.31234; Duct Radius: 0.82021; Lining Radius: 0.82021; Insulation Radius: 0.82021; Duct Diameter: 1.64042; PSet_Revit_Other - Length 1: 0.984252; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Vertical Profile Offset 2: 0.410105; Half Height: 0.82021; Vertical Profile Offset 1: 0.410105; Offset Width 1: 10; Offset Height 1: 10; Half Width: 1.31234
M_Round Takeoff:Standard:Standard:569461 | 2A14 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6967 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568239 | 1DC4 | Level 2 | Level : Level 2 | -1.07 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 4648 | 0.328084 | 0.0884751 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:570189 | 2D04-A | Roof - Main | Level : Roof - Main | -0.68 | 2.78871 | 0.656168 | 850x200-850x200 | Return Air | Mechanical Return Air 2 | 8708 | 0.697178 | 0.02 | 0.697178 | PSet_Revit_Dimensions - W1: 2.78871; W0: 2.78871; Length Multiplier: 0.25; H1: 0.656168; H0: 0.656168; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:567792 | 1D32 | Level 1 | Level : Level 1 | 3.79 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 3135 | 0.328084 | 0.279609 | 0.396559 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568036 | 1A16 | Level 2 | Level : Level 2 | -0.860497 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 4026 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569852 | 2B01 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 8058 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Oval Transition - Length:Standard:Standard:567590 | 1D32 | Level 1 | Level : Level 1 | 3.69 |  |  | 1500/500-1050/500 | Supply Air | Mechanical Supply Air 1 | 2560 | PSet_Revit_Other - Length 1: 1.47638; Width Offset: 10; Width 1: 1.47638; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Height Offset: 10; Height 1: 0; Half Width 2: 2.46063; Half Width 1: 1.72244; Half Height 2: 0.82021; Half Height 1: 0.82021; Height 2: 0; Width 2: 0; PSet_Revit_Dimensions - Duct Width 2: 4.92126; Duct Width 1: 3.44488; Lining Duct Width 2: 4.92126; Lining Duct Width 1: 3.44488; Lining Duct Height 2: 1.64042; Lining Duct Height 1: 1.64042; Duct Length: 1.9685; Insulation Duct Width 2: 4.92126; Insulation Duct Width 1: 3.44488; Insulation Duct Height 2: 1.64042; Insulation Duct Height 1: 1.64042; Duct Height 2: 1.64042; Duct Height 1: 1.64042; OffsetHeight: 0.82021; OffsetWidth: 1.72244
M_Round Takeoff:Standard:Standard:567743 | 1DC7 | Level 1 | Level : Level 1 | 3.3 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 2995 | 0.328084 | 0.131077 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Takeoff:Standard:Standard:567246 | 1D25 | Level 1 | Level : Level 1 | 3.8 | 1.47638 | 0.492126 | 450x150-450x150 | Return Air | Mechanical Return Air 1 | 1479 | 0.369094 | 0.02 | 0.369094 | PSet_Revit_Dimensions - W1: 1.47638; W0: 1.47638; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Oval to Round Transition - Length:Standard:Standard:568089 | 1CC3 | Level 2 | Level : Level 2 | -1.32 | 1.64042 | 0.984252 | 500/300-250ø | Supply Air | Mechanical Supply Air 1 | 4148 | PSet_Revit_Dimensions - Duct Width: 1.64042; Duct Height: 0.984252; Duct Length: 0.984252; OffsetHeight: 0.492126; OffsetWidth: 0.82021; Duct Radius: 0.410105; Lining Radius: 0.410105; Insulation Radius: 0.410105; Duct Diameter: 0.82021; PSet_Revit_Other - Length 1: 0.82021; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Vertical Profile Offset 2: 0.205052; Half Height: 0.492126; Vertical Profile Offset 1: 0.246063; Offset Width 1: 10; Offset Height 1: 10; Half Width: 0.82021
M_Round Takeoff:Standard:Standard:569828 | 2D07 | Roof - Main | Level : Roof - Main | -1.2705 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 8011 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:568630 | 1DC1 | Level 1 | Level : Level 1 | 3.20948 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5481 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:569972 | 2D14 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.656168 | 350x200-350x200 | Return Air | Mechanical Return Air 2 | 8341 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.656168; H0: 0.656168; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:567821 | 1D31 | Level 1 | Level : Level 1 | 3.31901 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 3222 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Oval to Round Transition - Length:Standard:Standard:567903 | 1A16 | Level 2 | Level : Level 2 | -0.87 | 2.29659 | 1.64042 | 700/500-350ø | Supply Air | Mechanical Supply Air 1 | 3456 | PSet_Revit_Dimensions - Duct Width: 2.29659; Duct Height: 1.64042; Duct Length: 0.984252; OffsetHeight: 0.82021; OffsetWidth: 1.14829; Duct Radius: 0.574147; Lining Radius: 0.574147; Insulation Radius: 0.574147; Duct Diameter: 1.14829; PSet_Revit_Other - Length 1: 1.14829; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Vertical Profile Offset 2: 0.287073; Half Height: 0.82021; Vertical Profile Offset 1: 0.410105; Offset Width 1: 10; Offset Height 1: 10; Half Width: 1.14829
M_Round Takeoff:Standard:Standard:567484 | 1BC2 | Level 1 | Level : Level 1 | 3.69 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 2236 | 0.328084 | 0.096959 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:567178 | 1CC1 | Level 1 | Level : Level 1 | 3.64 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 1 | 1390 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:567241 | 1D23 | Level 1 | Level : Level 1 | 3.8 | 1.31234 | 0.492126 | 400x150-400x150 | Return Air | Mechanical Return Air 1 | 1472 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.31234; W0: 1.31234; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:567513 | 1BC2 | Level 1 | Level : Level 1 | 3.37 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 2302 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:567326 | 1E24 | Level 1 | Level : Level 1 | 3.79 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 1669 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:567991 | 1A16 | Level 2 | Level : Level 2 | -0.8605 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 3868 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569270 | 2CC3 | Roof - Main | Level : Roof - Main | -1.18002 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6424 | 0.328084 | 0.02 | 0.416041 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:567044 | 1DC7 | Level 1 | Level : Level 1 | 3.64 | 4.42913 | 1.47638 | 1350x450-1350x450-250x450 | Return Air | Mechanical Return Air 1 | 1079 | PSet_Revit_Dimensions - Width: 4.42913; Length1: 0.492126; Height: 1.47638; Width3: 0.82021; Shoulder: 0.082021; Lining Width3: 0.82021; Length3a: 2.21457; Length3: 2.29659; Length1a: 0.410105; Insulation Width3: 0.82021
M_Oval Transition - Length:Standard:Standard:569518 | 2DC1 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 1000/400-900/400 | Supply Air | Mechanical Supply Air 2 | 7184 | PSet_Revit_Other - Length 1: 0.328084; Width Offset: 10; Width 1: 0.328084; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Height Offset: 10; Height 1: 0; Half Width 2: 1.47638; Half Width 1: 1.64042; Half Height 2: 0.656168; Half Height 1: 0.656168; Height 2: 0; Width 2: 0; PSet_Revit_Dimensions - Duct Width 2: 2.95276; Duct Width 1: 3.28084; Lining Duct Width 2: 2.95276; Lining Duct Width 1: 3.28084; Lining Duct Height 2: 1.31234; Lining Duct Height 1: 1.31234; Duct Length: 0.984252; Insulation Duct Width 2: 2.95276; Insulation Duct Width 1: 3.28084; Insulation Duct Height 2: 1.31234; Insulation Duct Height 1: 1.31234; Duct Height 2: 1.31234; Duct Height 1: 1.31234; OffsetHeight: 0.656168; OffsetWidth: 1.64042
M_Rectangular Takeoff:Standard:Standard:567077 | 1E06 | Level 1 | Level : Level 1 | 3.3 | 1.31234 | 0.492126 | 400x150-400x150 | Return Air | Mechanical Return Air 1 | 1179 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.31234; W0: 1.31234; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Rectangular Tee:Standard:Standard:569087 | 2A09 | Roof - Main | Level : Roof - Main | -0.73 | 3.1168 | 1.47638 | 950x450-950x450-750x450 | Return Air | Mechanical Return Air 2 | 5954 | PSet_Revit_Dimensions - Width: 3.1168; Length1: 1.31234; Height: 1.47638; Width3: 2.46063; Shoulder: 0.082021; Lining Width3: 2.46063; Length3a: 1.5584; Length3: 1.64042; Length1a: 1.23031; Insulation Width3: 2.46063
M_Rectangular Takeoff:Standard:Standard:570057 | 2BC3 | Roof - Main | Level : Roof - Main | -0.68 | 1.31234 | 0.492126 | 400x150-400x150 | Return Air | Mechanical Return Air 2 | 8506 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.31234; W0: 1.31234; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569475 | 2A09 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 2 | 7032 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Rectangular Takeoff:Standard:Standard:569998 | 2D07 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.82021 | 350x250-350x250 | Return Air | Mechanical Return Air 2 | 8379 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.82021; H0: 0.82021; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:567316 | 1E07 | Level 1 | Level : Level 1 | 3.5 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 1624 | 0.328084 | 0.0748925 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Takeoff:Standard:Standard:570017 | 2D07 | Roof - Main | Level : Roof - Main | -0.68 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 2 | 8399 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:567459 | 1BC2 | Level 1 | Level : Level 1 | 3.69 |  |  | 400ø-400ø | Supply Air | Mechanical Supply Air 1 | 2181 | 0.328084 | 0.348203 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.656168; Lining Diameter: 1.31234; Insulation Diameter: 1.31234; Diameter: 1.31234
M_Rectangular Takeoff:Standard:Standard:570066 | 2BC3 | Roof - Main | Level : Roof - Main | -0.68 | 0.656168 | 0.492126 | 200x150-200x150 | Return Air | Mechanical Return Air 2 | 8517 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.656168; W0: 0.656168; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568099 | 1C18 | Level 2 | Level : Level 2 | -1.27 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 4173 | 0.328084 | 0.0677834 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:569200 | 2C14 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 2 | 6233 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Rectangular Tee:Standard:Standard:568065 | 1C08 | Level 2 | Level : Level 2 | -1.21049 | 0.656168 | 0.984252 | 300x300-200x300-200x300 | Supply Air | Mechanical Supply Air 1 | 4075 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.574147; Height: 0.984252; Width3: 0.984252; Shoulder: 0.082021; Lining Width3: 0.984252; Length3a: 0.328084; Length3: 0.410105; Length1a: 0.492126; Insulation Width3: 0.984252
M_Round Takeoff:Standard:Standard:568175 | 1C01 | Level 2 | Level : Level 2 | -1.27 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 4415 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Tee:Standard:Standard:566824 | 1A16 | Level 2 | Level : Level 2 | -1.325 | 1.64042 | 0.656168 | 500x200-500x200-250x200 | Return Air | Mechanical Return Air 1 | 579 | PSet_Revit_Dimensions - Width: 1.64042; Length1: 0.492126; Height: 0.656168; Width3: 0.82021; Shoulder: 0.082021; Lining Width3: 0.82021; Length3a: 0.82021; Length3: 0.902231; Length1a: 0.410105; Insulation Width3: 0.82021
M_Round Takeoff:Standard:Standard:569633 | 2BC4 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 7476 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569656 | 2B15 | Roof - Main | Level : Roof - Main | -1.0455 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 7529 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Oval Elbow - Gored:Standard:Standard:567900 | 1A16 | Level 2 | Level : Level 2 | -0.87 | 2.29659 | 1.64042 | 700/500-700/500 | Supply Air | Mechanical Supply Air 1 | 3453 | PSet_Revit_Dimensions - Angle: 90 deg; Duct Width: 2.29659; Duct Height: 1.64042; Max Segmentation Angle: 22.5 deg; Gores: 5; Center Radius: 3.44488; PSet_Revit_Mechanical - ASHRAE Table: CF3-1; PSet_Revit_Other - Length 3: 3.60892; Length 2: 3.44488; Length 1: 3.44488; End Length: 0.164042; Length 5: 0.164042; Length 4: 1.00443e-17
M_Round Takeoff:Standard:Standard:567334 | 1E06 | Level 1 | Level : Level 1 | 3.79 |  |  | 400ø-400ø | Supply Air | Mechanical Supply Air 1 | 1698 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.656168; Lining Diameter: 1.31234; Insulation Diameter: 1.31234; Diameter: 1.31234
M_Rectangular Takeoff:Standard:Standard:567113 | 1E27 | Level 1 | Level : Level 1 | 3.79 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 1 | 1216 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:567204 | 1C15 | Level 1 | Level : Level 1 | 3.64 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 1 | 1432 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568800 | 1D24 | Level 1 | Level : Level 1 | 3.27 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5595 | 0.328084 | 0.133961 | 0.442045 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569804 | 2D18 | Roof - Main | Level : Roof - Main | -1.27052 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 7934 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Takeoff:Standard:Standard:569981 | 2D16 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8358 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568677 | 1EC4 | Level 1 | Level : Level 1 | 3.4095 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 5510 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:568131 | 1C18 | Level 2 | Level : Level 2 | -1.27 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 4289 | 0.328084 | 0.443981 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:566763 | 1DC1 | Level 2 | Level : Level 2 | -0.93 | 2.13255 | 0.984252 | 650x300-650x300-500x300 | Return Air | Mechanical Return Air 1 | 352 | PSet_Revit_Dimensions - Width: 2.13255; Length1: 0.902231; Height: 0.984252; Width3: 1.64042; Shoulder: 0.082021; Lining Width3: 1.64042; Length3a: 1.06627; Length3: 1.14829; Length1a: 0.82021; Insulation Width3: 1.64042; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Round Takeoff:Standard:Standard:568687 | 1E16 | Level 1 | Level : Level 1 | 3.4146 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 5516 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:567478 | 1B19 | Level 1 | Level : Level 1 | 3.6996 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 1 | 2222 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Round Takeoff:Standard:Standard:569274 | 2CC2 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 6440 | 0.328084 | 0.163947 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Tee:Standard:Standard:569113 | 2A03 | Roof - Main | Level : Roof - Main | -0.73 | 1.31234 | 0.656168 | 400x200-400x200-400x200 | Return Air | Mechanical Return Air 2 | 6077 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.738189; Height: 0.656168; Width3: 1.31234; Shoulder: 0.082021; Lining Width3: 1.31234; Length3a: 0.656168; Length3: 0.738189; Length1a: 0.656168; Insulation Width3: 1.31234; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Round Takeoff:Standard:Standard:567298 | 1E06 | Level 1 | Level : Level 1 | 3.79 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 1585 | 0.328084 | 0.279609 | 0.396559 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569839 | 2BC5 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 8030 | 0.328084 | 0.306037 | 0.32825 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:568453 | 1C16 | Level 1 | Level : Level 1 | 3.565 | 0.984252 | 0.984252 | 300x300-300x300 | Return Air | Mechanical Return Air 1 | 5251 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.984252; W0: 0.984252; Length Multiplier: 0.25; H1: 0.984252; H0: 0.984252; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568426 | 1EC1 | Level 2 | Level : Level 2 | -0.78 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 5221 | 0.328084 | 0.0754006 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:567576 | 1BC1 | Level 1 | Level : Level 1 | 3.79952 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 2431 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:567730 | 1DC7 | Level 1 | Level : Level 1 | 3.3 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 2970 | 0.328084 | 0.122976 | 0.328116 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:567052 | 1D26 | Level 1 | Level : Level 1 | 3.64 | 4.42913 | 1.47638 | 1350x450-1350x450-250x450 | Return Air | Mechanical Return Air 1 | 1087 | PSet_Revit_Dimensions - Width: 4.42913; Length1: 0.492126; Height: 1.47638; Width3: 0.82021; Shoulder: 0.082021; Lining Width3: 0.82021; Length3a: 2.21457; Length3: 2.29659; Length1a: 0.410105; Insulation Width3: 0.82021
M_Round Takeoff:Standard:Standard:567823 | 1E11 | Level 1 | Level : Level 1 | 3.69 |  |  | 350ø-350ø | Supply Air | Mechanical Supply Air 1 | 3233 | 0.328084 | 1.37261 | 1.68069 | PSet_Revit_Dimensions - Radius: 0.574147; Lining Diameter: 1.14829; Insulation Diameter: 1.14829; Diameter: 1.14829
M_Round Takeoff:Standard:Standard:567549 | 1B13 | Level 1 | Level : Level 1 | 3.79951 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 2367 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:570465 | 2D05 | Roof - Main | Level : Roof - Main | -3.78 | 2.46063 | 2.46063 | 750x750-750x750 | Supply Air | Mechanical Supply Air 2 | 9046 | 0.615157 | 0.02 | 0.615157 | PSet_Revit_Dimensions - W1: 2.46063; W0: 2.46063; Length Multiplier: 0.25; H1: 2.46063; H0: 2.46063; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569850 | 2B01 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 8047 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:568654 | 1D24 | Level 1 | Level : Level 1 | 3.27 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5496 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:567801 | 1DC7 | Level 1 | Level : Level 1 | 3.3095 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 3159 | 0.328084 | 0.173518 | 0.481602 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:567481 | 1BC2 | Level 1 | Level : Level 1 | 3.79 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 2229 | 0.328084 | 0.414068 | 0.3924 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:569322 | 2C01 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 6617 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:567541 | 1B17 | Level 1 | Level : Level 1 | 3.5 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 2346 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:569161 | 2AC2 | Roof - Main | Level : Roof - Main | -0.73 | 2.13255 | 1.31234 | 650x400-650x400-350x400 | Return Air | Mechanical Return Air 2 | 6161 | PSet_Revit_Dimensions - Width: 2.13255; Length1: 0.656168; Height: 1.31234; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 1.06627; Length3: 1.14829; Length1a: 0.574147; Insulation Width3: 1.14829; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Round Takeoff:Standard:Standard:567456 | 1B04 | Level 1 | Level : Level 1 | 3.7995 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 2171 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:569812 | 2D18 | Roof - Main | Level : Roof - Main | -1.28 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 7950 | 0.328084 | 0.30561 | 0.328326 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568643 | 1D22 | Level 1 | Level : Level 1 | 3.2095 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 5489 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Takeoff:Standard:Standard:568995 | 2C19 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 5700 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569330 | 2C03 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6642 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569691 | 2DC1 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 7614 | 0.328084 | 0.163947 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:567854 | 1E16 | Level 1 | Level : Level 1 | 3.4146 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 3351 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Cross:Standard:Standard:568194 | 1DC1 | Level 2 | Level : Level 2 | -1.36053 |  | 0.984252 | 300x300-300x300-150x300-150x300 | Supply Air | Mechanical Supply Air 1 | 4474 | PSet_Revit_Dimensions - Length1: 0.328084; Height: 0.984252; Width3: 0.492126; Shoulder: 0.082021; Lining Width3: 0.492126; Length3a: 0.492126; Length3: 0.574147; Length1a: 0.246063; Insulation Width3: 0.492126; Width4: 0.492126; Width1: 0.984252; Lining Width4: 0.492126; Lining Width1: 0.984252; Insulation Width4: 0.492126; Insulation Width1: 0.984252
M_Rectangular Takeoff:Standard:Standard:569056 | 2A11 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 5806 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568396 | 1E06 | Level 2 | Level : Level 2 | -0.770525 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5151 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Oval Elbow - Mitered:Standard:Standard:570441 | 2D05 | Roof - Main | Level : Roof - Main | -3.78 | 1.64042 | 4.92126 | 500/1500-500/1500 | Supply Air | Mechanical Supply Air 1 | 8984 | PSet_Revit_Dimensions - Angle: 90 deg; Shoulder Length: 0.082021; Duct Width: 1.64042; Duct Height: 4.92126; PSet_Revit_Other - Length 3: 0.902231; Length 2: 0.902231; Length 1: 0.902231
M_Round Takeoff:Standard:Standard:568651 | 1D30 | Level 1 | Level : Level 1 | 3.319 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 5494 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Takeoff:Standard:Standard:569965 | 2D15 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8330 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:569000 | Level 2 | Roof - Main | Level : Roof - Main | -0.68 | 1.47638 | 0.492126 | 450x150-450x150 | Return Air | Mechanical Return Air 2 | 5708 | 0.369094 | 0.02 | 0.369094 | PSet_Revit_Dimensions - W1: 1.47638; W0: 1.47638; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:570052 | 2BC3 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8502 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:567117 | 1E24 | Level 1 | Level : Level 1 | 3.79 | 1.64042 | 0.656168 | 500x200-500x200 | Return Air | Mechanical Return Air 1 | 1219 | 0.410105 | 0.02 | 0.410105 | PSet_Revit_Dimensions - W1: 1.64042; W0: 1.64042; Length Multiplier: 0.25; H1: 0.656168; H0: 0.656168; ConnectorOffset: 0
M_Oval Elbow - Gored:Standard:Standard:567287 | 1BC2 | Level 1 | Level : Level 1 | 3.69003 | 2.62467 | 1.64042 | 800/500-800/500 | Supply Air | Mechanical Supply Air 1 | 1554 | PSet_Revit_Dimensions - Angle: 90 deg; Duct Width: 2.62467; Duct Height: 1.64042; Max Segmentation Angle: 22.5 deg; Gores: 5; Center Radius: 3.93701; PSet_Revit_Mechanical - ASHRAE Table: CF3-1; PSet_Revit_Other - Length 3: 4.10105; Length 2: 3.93701; Length 1: 3.93701; End Length: 0.164042; Length 5: 0.164042; Length 4: 1.00443e-17
M_Rectangular Takeoff:Standard:Standard:570180 | 2D02 | Roof - Main | Level : Roof - Main | -0.68 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 2 | 8697 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568264 | 1DC3 | Level 2 | Level : Level 2 | -0.87 |  |  | 500ø-500ø | Supply Air | Mechanical Supply Air 1 | 4739 | 0.410105 | 0.84021 | 0.410105 | PSet_Revit_Dimensions - Radius: 0.82021; Lining Diameter: 1.64042; Insulation Diameter: 1.64042; Diameter: 1.64042
M_Rectangular Tee:Standard:Standard:567907 | 1A16 | Level 2 | Level : Level 2 | -0.93 | 2.13255 | 1.14829 | 650x350-650x350-550x350 | Return Air | Mechanical Return Air 1 | 3469 | PSet_Revit_Dimensions - Width: 2.13255; Length1: 0.984252; Height: 1.14829; Width3: 1.80446; Shoulder: 0.082021; Lining Width3: 1.80446; Length3a: 1.06627; Length3: 1.14829; Length1a: 0.902231; Insulation Width3: 1.80446; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Rectangular Tee:Standard:Standard:567352 | 1BC4 | Level 1 | Level : Level 1 | 3.3 | 0.492126 | 0.984252 | 300x300-150x300-150x300 | Supply Air | Mechanical Supply Air 1 | 1764 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.574147; Height: 0.984252; Width3: 0.984252; Shoulder: 0.082021; Lining Width3: 0.984252; Length3a: 0.246063; Length3: 0.328084; Length1a: 0.492126; Insulation Width3: 0.984252
M_Round Takeoff:Standard:Standard:568256 | 1D13 | Level 2 | Level : Level 2 | -1.0605 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 4728 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:567168 | 1D09 | Level 1 | Level : Level 1 | 3.3 | 1.14829 | 0.656168 | 350x200-350x200 | Return Air | Mechanical Return Air 1 | 1365 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.656168; H0: 0.656168; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:570073 | 2B10 | Roof - Main | Level : Roof - Main | -0.68 | 1.64042 | 1.14829 | 500x350-500x350 | Return Air | Mechanical Return Air 2 | 8524 | 0.410105 | 0.02 | 0.410105 | PSet_Revit_Dimensions - W1: 1.64042; W0: 1.64042; Length Multiplier: 0.25; H1: 1.14829; H0: 1.14829; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568028 | 1AC3 | Level 2 | Level : Level 2 | -0.8355 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 3994 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569860 | 2BC5 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 8084 | 0.328084 | 0.0905204 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569444 | 2AC3 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 6888 | 0.328084 | 0.163947 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:568278 | 1DC3 | Level 2 | Level : Level 2 | -0.869996 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 4807 | 0.328084 | 0.0884805 | 0.328212 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568223 | 1D16 | Level 2 | Level : Level 2 | -1.27 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 4593 | 0.328084 | 0.02 | 0.492126 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:567682 | 1DC6 | Level 1 | Level : Level 1 | 3.79 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 2829 | 0.328084 | 0.217294 | 0.400428 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:568023 | 1AC3 | Level 2 | Level : Level 2 | -0.87 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 3985 | 0.328084 | 0.308084 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569692 | 2DC1 | Roof - Main | Level : Roof - Main | -1.08003 |  |  | 350ø-350ø | Supply Air | Mechanical Supply Air 2 | 7618 | 0.328084 | 0.358502 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.574147; Lining Diameter: 1.14829; Insulation Diameter: 1.14829; Diameter: 1.14829
M_Oval Elbow - Gored:Standard:Standard:1115315 | 2D05 | Level 2 | Level : Level 2 | 3.6 | 4.59318 | 1.31234 | 1400/400-1400/400 | Supply Air | Mechanical Supply Air 2 | 750 | PSet_Revit_Dimensions - Angle: 24.3464 deg; Duct Width: 4.59318; Duct Height: 1.31234; Max Segmentation Angle: 24.3464 deg; Gores: 2; Center Radius: 6.88976; PSet_Revit_Other - Length 3: 0.680336; Length 2: 2.98978; Length 1: 1.48625; End Length: 0.164042; Length 5: 0.0676267; Length 4: 0.149454
M_Rectangular Tee:Standard:Standard:567194 | 1D16 | Level 1 | Level : Level 1 | 3.64 | 1.47638 | 0.82021 | 450x250-450x250-450x250 | Return Air | Mechanical Return Air 1 | 1409 | PSet_Revit_Dimensions - Width: 1.47638; Length1: 0.82021; Height: 0.82021; Width3: 1.47638; Shoulder: 0.082021; Lining Width3: 1.47638; Length3a: 0.738189; Length3: 0.82021; Length1a: 0.738189; Insulation Width3: 1.47638; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Rectangular Takeoff:Standard:Standard:570445 | 2D05 | Level 2 | Level : Level 2 | 0.9 | 2.95276 | 2.95276 | 900x900-900x900 | Supply Air | Mechanical Supply Air 1 | 8996 | 0.738189 | 0.02 | 0.738189 | PSet_Revit_Dimensions - W1: 2.95276; W0: 2.95276; Length Multiplier: 0.25; H1: 2.95276; H0: 2.95276; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:567819 | 1D30 | Level 1 | Level : Level 1 | 3.319 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 3217 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:568389 | 1E06 | Level 2 | Level : Level 2 | -1.27 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5140 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568684 | 1E16 | Level 1 | Level : Level 1 | 3.4146 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 5514 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Tee:Standard:Standard:568537 | 1BC2 | Level 1 | Level : Level 1 | 3.3 | 0.984252 | 0.984252 | 300x300-300x300-300x300 | Return Air | Mechanical Return Air 1 | 5384 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.984252; Width3: 0.984252; Shoulder: 0.082021; Lining Width3: 0.984252; Length3a: 0.492126; Length3: 0.574147; Length1a: 0.492126; Insulation Width3: 0.984252
M_Round Takeoff:Standard:Standard:567689 | 1E11 | Level 1 | Level : Level 1 | 3.7995 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 2841 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569317 | 2C01 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6611 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:567402 | 1EC1 | Level 1 | Level : Level 1 | 3.79 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 2013 | 0.328084 | 0.10791 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:567842 | 1EC1 | Level 1 | Level : Level 1 | 3.4 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 3292 | 0.328084 | 0.192328 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:568243 | 1DC4 | Level 2 | Level : Level 2 | -1.07 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 4653 | 0.328084 | 0.129887 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Tee:Standard:Standard:569127 | 2A01 | Roof - Main | Level : Roof - Main | -0.73 | 1.31234 | 1.14829 | 400x350-400x350-250x350 | Return Air | Mechanical Return Air 2 | 6105 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.492126; Height: 1.14829; Width3: 0.82021; Shoulder: 0.082021; Lining Width3: 0.82021; Length3a: 0.656168; Length3: 0.738189; Length1a: 0.410105; Insulation Width3: 0.82021; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Round Takeoff:Standard:Standard:567845 | 1E16 | Level 1 | Level : Level 1 | 3.4146 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 3296 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular to Oval Transition - Length:Standard:Standard:1115316 | 2D05 | Level 2 | Level : Level 2 | 3.6 |  |  | 750x750-1400/400 | Supply Air | Mechanical Supply Air 2 | 752 | PSet_Revit_Other - Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Half Width 2: 2.29659; Half Width 1: 1.23031; Half Height 2: 0.656168; Half Height 1: 1.23031; Vertical Profile Offset 2: 0.615157; Vertical Profile Offset 1: 0.328084; Offset Width 1: 10; Offset Height 1: 10; PSet_Revit_Dimensions - Duct Width 2: 4.59318; Duct Width 1: 2.46063; Duct Length: 0.984252; Duct Height 2: 1.31234; Duct Height 1: 2.46063; OffsetHeight: 1.23031; OffsetWidth: 1.23031; Lining Width 2: 4.59318; Lining Height 2: 1.31234; Insulation Width 2: 4.59318; Insulation Height 2: 1.31234; Lining Width 1: 2.46063; Lining Height 1: 2.46063; Insulation Width 1: 2.46063; Insulation Height 1: 2.46063
M_Round Takeoff:Standard:Standard:568702 | 1E26 | Level 1 | Level : Level 1 | 3.5 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5525 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:570184 | 2D04 | Roof - Main | Level : Roof - Main | -0.68 | 1.31234 | 0.492126 | 400x150-400x150 | Return Air | Mechanical Return Air 2 | 8701 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.31234; W0: 1.31234; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569875 | 2B7 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 8124 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:567089 | 1E24 | Level 1 | Level : Level 1 | 3.79 | 1.64042 | 0.656168 | 500x200-500x200 | Return Air | Mechanical Return Air 1 | 1192 | 0.410105 | 0.02 | 0.410105 | PSet_Revit_Dimensions - W1: 1.64042; W0: 1.64042; Length Multiplier: 0.25; H1: 0.656168; H0: 0.656168; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:570538 | 1D40 | Level 2 | Level : Level 2 | -1.25094 | 0.82021 | 0.492126 | 250x150-250x150 | Supply Air | Default Supply Air (cskender) | 9241 | 0.328084 | 0.0200001 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568111 | 1CC1 | Level 2 | Level : Level 2 | -1.32 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 1 | 4231 | 0.328084 | 0.512126 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Rectangular Takeoff:Standard:Standard:569007 | 2C09 | Roof - Main | Level : Roof - Main | -0.68 | 1.47638 | 0.492126 | 450x150-450x150 | Return Air | Mechanical Return Air 2 | 5720 | 0.369094 | 0.02 | 0.369094 | PSet_Revit_Dimensions - W1: 1.47638; W0: 1.47638; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:569891 | 2B11 | Level 2 | Level : Level 2 | 3.60952 | 0.984252 | 0.984252 | 300x300-300x300 | Supply Air | Mechanical Supply Air 2 | 8174 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.984252; W0: 0.984252; Length Multiplier: 0.25; H1: 0.984252; H0: 0.984252; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:567510 | 1BC2 | Level 1 | Level : Level 1 | 3.4 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 2297 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569272 | 2CC2 | Roof - Main | Level : Roof - Main | -1.18002 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6432 | 0.328084 | 0.02 | 0.416041 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568660 | 1D28 | Level 1 | Level : Level 1 | 3.2905 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 5500 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:567724 | 1D38 | Level 1 | Level : Level 1 | 3.69 |  |  | 350ø-350ø | Supply Air | Mechanical Supply Air 1 | 2953 | 0.328084 | 0.254542 | 0.343044 | PSet_Revit_Dimensions - Radius: 0.574147; Lining Diameter: 1.14829; Insulation Diameter: 1.14829; Diameter: 1.14829
M_Round Takeoff:Standard:Standard:567425 | 1BC3 | Level 1 | Level : Level 1 | 3.78048 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 2079 | 0.328084 | 0.368573 | 0.375811 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Oval Tee - Straight:Standard:Standard:568082 | 1D11 | Level 2 | Level : Level 2 | -0.87 |  |  | 900/500-900/500-500/300 | Supply Air | Mechanical Supply Air 1 | 4130 | PSet_Revit_Mechanical - ASHRAE Table: SF5-1; PSet_Revit_Dimensions - Shoulder Length: 0.082021; Duct Width 2: 1.64042; Duct Width 1: 2.95276; Duct Height 2: 0.984252; Duct Height 1: 1.64042; Lining Width 2: 1.64042; Lining Height 2: 0.984252; Insulation Width 2: 1.64042; Insulation Height 2: 0.984252; Lining Width 1: 2.95276; Lining Height 1: 1.64042; Insulation Width 1: 2.95276; Insulation Height 1: 1.64042; PSet_Revit_Other - Length 2: 1.5584; Length 1: 1.80446
M_Round Takeoff:Standard:Standard:568062 | 1CC2 | Level 2 | Level : Level 2 | -1.22 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 4070 | 0.328084 | 0.211948 | 0.349346 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Takeoff:Standard:Standard:567262 | 1B13 | Level 1 | Level : Level 1 | 3.3 | 2.13255 | 0.656168 | 650x200-650x200 | Return Air | Mechanical Return Air 1 | 1486 | 0.533136 | 0.02 | 0.533136 | PSet_Revit_Dimensions - W1: 2.13255; W0: 2.13255; Length Multiplier: 0.25; H1: 0.656168; H0: 0.656168; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568145 | 1CC1 | Level 2 | Level : Level 2 | -1.27 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 4331 | 0.328084 | 0.0577872 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:568665 | 1E14 | Level 1 | Level : Level 1 | 3.29998 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 5503 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Tee:Standard:Standard:569156 | 2AC2 | Roof - Main | Level : Roof - Main | -0.73 | 2.46063 | 1.31234 | 750x400-750x400-350x400 | Return Air | Mechanical Return Air 2 | 6152 | PSet_Revit_Dimensions - Width: 2.46063; Length1: 0.656168; Height: 1.31234; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 1.23031; Length3: 1.31234; Length1a: 0.574147; Insulation Width3: 1.14829; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Round Takeoff:Standard:Standard:568288 | 1DC3 | Level 2 | Level : Level 2 | -0.869995 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 4831 | 0.328084 | 0.0969226 | 0.32827 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:567501 | 1BC2 | Level 1 | Level : Level 1 | 3.37 | 0.328084 | 0.656168 | 150x200-100x200-100x200 | Supply Air | Mechanical Supply Air 1 | 2277 | PSet_Revit_Dimensions - Width: 0.328084; Length1: 0.328084; Height: 0.656168; Width3: 0.492126; Shoulder: 0.082021; Lining Width3: 0.492126; Length3a: 0.164042; Length3: 0.246063; Length1a: 0.246063; Insulation Width3: 0.492126
M_Round Takeoff:Standard:Standard:568124 | 1C18 | Level 2 | Level : Level 2 | -1.32 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 4277 | 0.328084 | 0.131079 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:567787 | 1D34 | Level 1 | Level : Level 1 | 3.3096 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 3130 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569432 | 2AC3 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6868 | 0.328084 | 0.107919 | 0.32829 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:567226 | 1D25 | Level 1 | Level : Level 1 | 3.8 | 1.80446 | 0.984252 | 550x300-550x300 | Return Air | Mechanical Return Air 1 | 1456 | 0.451115 | 0.02 | 0.451115 | PSet_Revit_Dimensions - W1: 1.80446; W0: 1.80446; Length Multiplier: 0.25; H1: 0.984252; H0: 0.984252; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:567110 | 1E24 | Level 1 | Level : Level 1 | 3.79 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 1 | 1214 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:567870 | 1EC4 | Level 1 | Level : Level 1 | 3.4095 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 3384 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Oval to Round Transition - Length:Standard:Standard:567696 | 1D34 | Level 1 | Level : Level 1 | 3.69 | 1.9685 | 1.64042 | 600/500-500ø | Supply Air | Mechanical Supply Air 1 | 2855 | PSet_Revit_Dimensions - Duct Width: 1.9685; Duct Height: 1.64042; Duct Length: 0.984252; OffsetHeight: 0.82021; OffsetWidth: 0.984252; Duct Radius: 0.82021; Lining Radius: 0.82021; Insulation Radius: 0.82021; Duct Diameter: 1.64042; PSet_Revit_Other - Length 1: 0.328084; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Vertical Profile Offset 2: 0.410105; Half Height: 0.82021; Vertical Profile Offset 1: 0.410105; Offset Width 1: 10; Offset Height 1: 10; Half Width: 0.984252
M_Oval Transition - Length:Standard:Standard:569072 | 2AC3 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 900/400-700/400 | Supply Air | Mechanical Supply Air 2 | 5878 | PSet_Revit_Other - Length 1: 0.656168; Width Offset: 10; Width 1: 0.656168; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Height Offset: 10; Height 1: 0; Half Width 2: 1.14829; Half Width 1: 1.47638; Half Height 2: 0.656168; Half Height 1: 0.656168; Height 2: 0; Width 2: 0; PSet_Revit_Dimensions - Duct Width 2: 2.29659; Duct Width 1: 2.95276; Lining Duct Width 2: 2.29659; Lining Duct Width 1: 2.95276; Lining Duct Height 2: 1.31234; Lining Duct Height 1: 1.31234; Duct Length: 0.984252; Insulation Duct Width 2: 2.29659; Insulation Duct Width 1: 2.95276; Insulation Duct Height 2: 1.31234; Insulation Duct Height 1: 1.31234; Duct Height 2: 1.31234; Duct Height 1: 1.31234; OffsetHeight: 0.656168; OffsetWidth: 1.47638
M_Rectangular Tee:Standard:Standard:567596 | 1D25 | Level 1 | Level : Level 1 | 3.2905 | 0.984252 | 0.82021 | 400x250-300x250-300x250 | Supply Air | Mechanical Supply Air 1 | 2580 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.738189; Height: 0.82021; Width3: 1.31234; Shoulder: 0.082021; Lining Width3: 1.31234; Length3a: 0.492126; Length3: 0.574147; Length1a: 0.656168; Insulation Width3: 1.31234
M_Round Takeoff:Standard:Standard:567452 | 1BC2 | Level 1 | Level : Level 1 | 3.79 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 2162 | 0.328084 | 0.185939 | 0.392418 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Cross:Standard:Standard:567603 | 1D25 | Level 1 | Level : Level 1 | 3.2905 |  | 0.82021 | 300x250-300x250-200x250-100x250 | Supply Air | Mechanical Supply Air 1 | 2595 | PSet_Revit_Dimensions - Length1: 0.410105; Height: 0.82021; Width3: 0.656168; Shoulder: 0.082021; Lining Width3: 0.656168; Length3a: 0.492126; Length3: 0.574147; Length1a: 0.328084; Insulation Width3: 0.656168; Width4: 0.328084; Width1: 0.984252; Lining Width4: 0.328084; Lining Width1: 0.984252; Insulation Width4: 0.328084; Insulation Width1: 0.984252
M_Round Takeoff:Standard:Standard:569271 | 2CC2 | Roof - Main | Level : Roof - Main | -1.18 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6428 | 0.328084 | 0.588258 | 0.415994 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569304 | 2C01 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6585 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568705 | 1E26 | Level 1 | Level : Level 1 | 3.5 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5527 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569273 | 2CC2 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 6436 | 0.328084 | 0.163947 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:567560 | 1B04 | Level 1 | Level : Level 1 | 3.79 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 2381 | 0.328084 | 0.240093 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:568695 | 1E16 | Level 1 | Level : Level 1 | 3.4146 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 5521 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569861 | 2BC5 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 8088 | 0.328084 | 0.0859324 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Takeoff:Standard:Standard:1138927 | 1D09 | Level 1 | Level : Level 1 | 3.3 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 1 | 1568 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569813 | 2D18 | Roof - Main | Level : Roof - Main | -1.28 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 7954 | 0.328084 | 0.102021 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Takeoff:Standard:Standard:569028 | 2A09 | Roof - Main | Level : Roof - Main | -0.68 | 1.31234 | 0.492126 | 400x150-400x150 | Return Air | Mechanical Return Air 2 | 5747 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.31234; W0: 1.31234; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568803 | 1E33 | Level 1 | Level : Level 1 | 3.29999 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5597 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:1138423 | 1E11 | Level 1 | Level : Level 1 | 3.3 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 1 | 1438 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:570520 | 1B02 | Level 2 | Level : Level 2 | -0.7895 | 0.82021 | 0.492126 | 250x150-250x150 | Supply Air | Default Supply Air (cskender) | 9179 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Oval Elbow - Mitered:Standard:Standard:1114453 | 2D05 | Level 2 | Level : Level 2 | 3.3 | 1.64042 | 4.92126 | 500/1500-500/1500 | Supply Air | Mechanical Supply Air 1 | 704 | PSet_Revit_Dimensions - Angle: 90 deg; Shoulder Length: 0.082021; Duct Width: 1.64042; Duct Height: 4.92126; PSet_Revit_Other - Length 3: 0.902231; Length 2: 0.902231; Length 1: 0.902231
M_Rectangular Takeoff:Standard:Standard:570071 | 2B14 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.656168 | 350x200-350x200 | Return Air | Mechanical Return Air 2 | 8522 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.656168; H0: 0.656168; ConnectorOffset: 0
M_Rectangular to Oval Transition - Length:Standard:Standard:570442 | 2D05 | Roof - Main | Level : Roof - Main | -3.78 |  |  | 900x900-1500/500 | Supply Air | Mechanical Supply Air 1 | 8985 | PSet_Revit_Other - Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Half Width 2: 2.46063; Half Width 1: 1.47638; Half Height 2: 0.82021; Half Height 1: 1.47638; Vertical Profile Offset 2: 0.738189; Vertical Profile Offset 1: 0.410105; Offset Width 1: 10; Offset Height 1: 10; PSet_Revit_Dimensions - Duct Width 2: 4.92126; Duct Width 1: 2.95276; Duct Length: 0.984252; Duct Height 2: 1.64042; Duct Height 1: 2.95276; OffsetHeight: 1.47638; OffsetWidth: 1.47638; Lining Width 2: 4.92126; Lining Height 2: 1.64042; Insulation Width 2: 4.92126; Insulation Height 2: 1.64042; Lining Width 1: 2.95276; Lining Height 1: 2.95276; Insulation Width 1: 2.95276; Insulation Height 1: 2.95276
