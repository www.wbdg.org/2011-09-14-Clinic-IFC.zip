Properties of the parts of a building model (IFC2X3), part 28 of 295

# IfcFlowFitting: Rectangular Transition - 45 Degree (102)
Name (M_Rectangular Transition - Angle:Rectangular Transition - 45 Degree:Rectangular Transition - 45 Degree:...) | In | Mark | System Type | System Name | ASHRAE Table | Level | Host | Offset (m) | Num8 | Num7 | Num6 | Num5 | Num4 | Num3 | Num2 | Num1 | Length 2 | Length 1 | Delta 2 | Delta 1 | WidthOffset | WidthDelta | Width2 = Lining Width 2 = Insulation Width 2 | Width1 = Lining Width 1 = Insulation Width 1 | MaxDelta = Length 01 = Computed Length | Lining Height 2 = Insulation Height 2 = Height2 | Lining Height 1 = Insulation Height 1 = Height1 | HeightOffset | HeightDelta | Half Width 2 | Half Width 1 | Half Height 2 | Half Height 1 | Size | OffsetHeight | OffsetWidth
1138257 | 1D36 | 1327 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 2.9016 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0.396032 | 0.396032 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.492126 | 0.328084 | 0.492126 | 0.328084 | 300x300-200x200 | 0.328084 | 0.328084
1099607 | 1C05 | 379 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.35893 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0.594049 | 0.198016 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.574147 | 0.492126 | 300x300-150x350 | 0.492126 | 0.492126

# IfcFlowFitting: Rectangular to Round Transition - 45 Degree (66)
Type - ElementType: Rectangular to Round Transition - 45 Degree
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Dimensions - OffsetWidthfromBase: 10; OffsetHeightfromBase: 10
PSet_Revit_Mechanical - Lining Thickness: 0; Insulation Thickness: 0; Loss Method: 1
PSet_Revit_Other - Num 9: 1; Length 4: 0; Num 4: 1; Length 3: 0; TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
PSet_Revit_Type_Constraints - Angle: 45 deg
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Rectangular to Round Transition - Angle:Rectangular to Round Transition - 45 Degree:Rectangular to Round Transition - 45 Degree:...) | In | Mark | Delta 2 = Length 6 = Length 5 | Delta 1 = Length 2 = Length 1 | W0 = Lining W0 = Insulation W0 | Radius = Lining Radius = Insulation Radius | Lining H0 = Insulation H0 = H0 | Length01 | OffsetWidthTemp | OffsetHeightTemp | Diameter | Size | OffsetHeight = Half H0 | OffsetWidth = Half W0 | Level | Host | Offset (m) | System Type | System Name | ASHRAE Table | Num 8 | Num 7 = Num 6 | Num 10 | Num 1 = Num 2 | Length 8 | Length 7 | Num 5 | Num 3
995204 | 1E16 | 71 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
998455 | 1C19 | 144 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
995647 | 1B19 | 108 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
995645 | 2D08 | 106 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 2 | Level : Level 2 | 2.9016 | Supply Air | Mechanical Supply Air 2 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
995700 | 2C17 | 121 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 2 | Level : Level 2 | 2.9016 | Supply Air | Mechanical Supply Air 2 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
998463 | 1C17 | 152 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1115859 | 2A01 | 784 | 0.082021 | 0.082021 | 0.984252 | 0.410105 | 0.984252 | 0.198016 | -0.0416667 | 0.0416667 | 0.82021 | 300x300-250ø | 0.492126 | 0.492126 | Level 2 | Level : Level 2 | 2.9016 | Supply Air | Mechanical Supply Air 2 | SR4-3 | 2 | 1 | 2.41421 | 1 | 0.198016 | 0.198016 | 2.41421 | 2
1111606 | 1DC1 | 523 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1119985 | 1E16 | 1050 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1108448 | 1D38 | 460 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1115249 | 2C19 | 741 | 0.164042 | 0.164042 | 0.984252 | 0.328084 | 0.984252 | 0.396032 | -0.0416667 | 0.0416667 | 0.656168 | 300x300-200ø | 0.492126 | 0.492126 | Level 2 | Level : Level 2 | 2.9016 | Supply Air | Mechanical Supply Air 2 | SR4-3 | 4 | 2 | 4.82843 | 2 | 0.396032 | 0.396032 | 4.82843 | 4
1117171 | 2BC1 | 852 | 0.246063 | 0.410105 | 1.31234 | 0.246063 | 0.984252 | 0.990081 | -0.0555556 | 0.0416667 | 0.492126 | 400x300-150ø | 0.492126 | 0.656168 | Level 2 | Level : Level 2 | 3.3595 | Supply Air | Default Supply Air (cskender) | SR4-3 | 6 | 3 | 7.24264 | 5 | 0.990081 | 0.594049 | 12.0711 | 10
570727 | 1DC1 | 578 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
570730 | 1DC1 | 581 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1114556 | 2BC3 | 708 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 2 | Level : Level 2 | 2.9016 | Supply Air | Mechanical Supply Air 2 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1115936 | 2C17 | 803 | 0 | 0 | 0.984252 | 0.492126 | 0.984252 | 0.246063 | -0.0416667 | 0.0416667 | 0.984252 | 300x300-300ø | 0.492126 | 0.492126 | Level 2 | Level : Level 2 | 2.9016 | Supply Air | Mechanical Supply Air 2 | SR4-3 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0
570722 | 1D40 | 575 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1119982 | 1E16 | 1048 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1111608 | 1DC1 | 524 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 3.20948 | Supply Air | Mechanical Supply Air 1 | SD4-2 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1120160 | 1D40 | 1057 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
998458 | 1C18 | 146 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1107116 | 1DC4 | 454 | 0.164042 | 0.164042 | 0.984252 | 0.328084 | 0.984252 | 0.396032 | -0.0416667 | 0.0416667 | 0.656168 | 300x300-200ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 4 | 2 | 4.82843 | 2 | 0.396032 | 0.396032 | 4.82843 | 4
1110434 | 1DC3 | 476 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
571098 | 2D04-A | 27 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 2 | Level : Level 2 | 2.9016 | Supply Air | Mechanical Supply Air 2 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
570718 | 1E08 | 573 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1119415 | 1C09 | 973 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
570667 | 1A16 | 417 | 0.164042 | 0.082021 | 0.656168 | 0.246063 | 0.82021 | 0.396032 | -0.0277778 | 0.0347222 | 0.492126 | 200x250-150ø | 0.410105 | 0.328084 | Level 2 | Level : Level 2 | -0.8605 | Supply Air | Mechanical Supply Air 1 | SD4-2 | 4 | 2 | 4.82843 | 1 | 0.198016 | 0.396032 | 2.41421 | 2
1114887 | 2D16 | 714 | 0 | 0.246063 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | -0.0208333 | 0.0416667 | 0.984252 | 300ø-150x300 | 0.492126 | 0.246063 | Level 2 | Level : Level 2 | 3.6095 | Supply Air | Mechanical Supply Air 2 | SD4-2 | 0 | 0 | 0 | 3 | 0.594049 | 0 | 7.24264 | 6
570621 | 1B01 | 272 | 0.164042 | 0 | 0.82021 | 0.410105 | 0.492126 | 0.396032 | -0.0347222 | 0.0208333 | 0.82021 | 250ø-250x150 | 0.246063 | 0.410105 | Level 2 | Level : Level 2 | -1.116 | Supply Air | Default Supply Air (cskender) | SR4-3 | 4 | 2 | 4.82843 | 0 | 0 | 0.396032 | 0 | 0
1107873 | 1A02 | 459 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1122130 | 2D01 | 1251 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 2 | Level : Level 2 | 2.9016 | Supply Air | Mechanical Supply Air 2 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
570736 | 1DC1 | 586 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1114763 | 2B17 | 709 | 0.164042 | 0.164042 | 0.984252 | 0.328084 | 0.984252 | 0.396032 | -0.0416667 | 0.0416667 | 0.656168 | 300x300-200ø | 0.492126 | 0.492126 | Level 2 | Level : Level 2 | 2.9016 | Supply Air | Mechanical Supply Air 2 | SR4-3 | 4 | 2 | 4.82843 | 2 | 0.396032 | 0.396032 | 4.82843 | 4
570622 | 1B01 | 273 | 0 | 0.164042 | 1.14829 | 0.410105 | 0.82021 | 0.396032 | -0.0486111 | 0.0347222 | 0.82021 | 350x250-250ø | 0.410105 | 0.574147 | Level 2 | Level : Level 2 | -1.116 | Supply Air | Default Supply Air (cskender) | SD4-2 | 0 | 0 | 0 | 2 | 0.396032 | 0 | 4.82843 | 4
570720 | 1D38 | 574 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
570733 | 1DC1 | 583 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1106780 | 1A16 | 452 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1119304 | 1B14 | 940 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1119299 | 1B10 | 937 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1119073 | 1D21 | 908 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
998466 | 1C15 | 154 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1119301 | 1B12 | 938 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1120856 | 1DC6 | 1132 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
570599 | 1A05 | 164 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
570748 | 1C04 | 637 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1114885 | 2D16 | 710 | 0 | 0 | 0.984252 | 0.492126 | 0.984252 | 0.246063 | -0.0416667 | 0.0416667 | 0.984252 | 300x300-300ø | 0.492126 | 0.492126 | Level 2 | Level : Level 2 | 2.9016 | Supply Air | Mechanical Supply Air 2 | SR4-3 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0
1121408 | 1D06 | 1177 | 0.164042 | 0.164042 | 0.984252 | 0.328084 | 0.984252 | 0.396032 | -0.0416667 | 0.0416667 | 0.656168 | 300x300-200ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 4 | 2 | 4.82843 | 2 | 0.396032 | 0.396032 | 4.82843 | 4
571085 | 2D04 | 21 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 2 | Level : Level 2 | 2.9016 | Supply Air | Mechanical Supply Air 2 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1120161 | 1D40 | 1058 | 0.164042 | 0 | 0.492126 | 0.246063 | 0.82021 | 0.396032 | -0.0208333 | 0.0347222 | 0.492126 | 150x250-150ø | 0.410105 | 0.246063 | Level 1 | Level : Level 1 | 3.30951 | Supply Air | Mechanical Supply Air 1 | SD4-2 | 4 | 2 | 4.82843 | 0 | 0 | 0.396032 | 0 | 0
1122734 | 1D37 | 1274 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Default Supply Air (cskender) | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
570638 | 1D02 | 326 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 2 | Level : Level 2 | -1.6684 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1121991 | 2D10 | 1237 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 2 | Level : Level 2 | 2.9016 | Supply Air | Mechanical Supply Air 2 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1131963 | 1D16 | 1296 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1117467 | 1E27 | 866 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1122498 | 2AC3 | 1273 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 2 | Level : Level 2 | 2.9016 | Supply Air | Mechanical Supply Air 2 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1119242 | 1D16 | 929 | 0.164042 | 0.164042 | 0.984252 | 0.328084 | 0.984252 | 0.396032 | -0.0416667 | 0.0416667 | 0.656168 | 300x300-200ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 4 | 2 | 4.82843 | 2 | 0.396032 | 0.396032 | 4.82843 | 4
1117468 | 1E27 | 867 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 3.5096 | Supply Air | Mechanical Supply Air 1 | SD4-2 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
570751 | 1C05 | 639 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1112952 | 1D25 | 660 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1125436 | 1B08 | 1291 | 0.082021 | 0.082021 | 0.328084 | 0.246063 | 0.656168 | 0.198016 | -0.0138889 | 0.0277778 | 0.492126 | 100x200-150ø | 0.328084 | 0.164042 | Level 1 | Level : Level 1 | 3.5 | Supply Air | Mechanical Supply Air 1 | SD4-2 | 2 | 1 | 2.41421 | 1 | 0.198016 | 0.198016 | 2.41421 | 2
570698 | 1A15 | 517 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 2 | Level : Level 2 | -1.6684 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1125396 | 1BC3 | 1288 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1120352 | 1C18 | 1097 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1119071 | 1D33 | 906 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1125435 | 1B08 | 1290 | 0.246063 | 0.246063 | 0.984252 | 0.246063 | 0.984252 | 0.594049 | -0.0416667 | 0.0416667 | 0.492126 | 300x300-150ø | 0.492126 | 0.492126 | Level 1 | Level : Level 1 | 2.9016 | Supply Air | Mechanical Supply Air 1 | SR4-3 | 6 | 3 | 7.24264 | 3 | 0.594049 | 0.594049 | 7.24264 | 6
1091312 | 2D05 | 267 | 0.574147 | 0.574147 | 1.47638 | 0.164042 | 1.47638 | 1.38611 | -0.0625 | 0.0625 | 0.328084 | 450x450-100ø | 0.738189 | 0.738189 | Level 2 | Level : Level 2 | 4.7435 | Exhaust Air | Mechanical Exhaust Air 1 |  | 14 | 7 | 16.8995 | 7 | 1.38611 | 1.38611 | 16.8995 | 14

# IfcFlowFitting: Round Elbow - 1 D (38)
Type - ElementType: Round Elbow - 1 D
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Lining Thickness: 0; Insulation Thickness: 0; System Type: Supply Air; Loss Method: 1
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Dimensions - Radius Multiplier: 1
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
Name (M_Round Elbow:Round Elbow - 1 D:Round Elbow - 1 D:...) | In | Mark | Radius = Lining Radius = Insulation Radius | Length1 | Center Radius | Angle (deg) | Size | Level | Host | Offset (m) | System Name | ASHRAE Table
994207 | 1DC6 | 50 | 0.738189 | 0.611536 | 1.47638 | 45 | 450ø-450ø | Level 1 | Level : Level 1 | 3.69 | Mechanical Supply Air 1
994210 | Level 1 | 52 | 0.738189 | 0.611536 | 1.47638 | 45 | 450ø-450ø | Level 1 | Level : Level 1 | 3.2905 | Mechanical Supply Air 1
998645 | 1D16 | 185 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Level 1 | Level : Level 1 | 3.36986 | Mechanical Supply Air 1 | CD3-11
998628 | 1D16 | 177 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Level 1 | Level : Level 1 | 3.36986 | Mechanical Supply Air 1 | CD3-11
1121927 | 2D18 | 1222 | 0.574147 | 0.307684 | 1.14829 | 30 | 350ø-350ø | Level 2 | Level : Level 2 | 3.4 | Mechanical Supply Air 2
1111826 | 1DC1 | 588 | 0.328084 | 0.271794 | 0.656168 | 45 | 200ø-200ø | Level 1 | Level : Level 1 | 2.94 | Mechanical Supply Air 1 | CD3-17
1121936 | 2D18 | 1233 | 0.574147 | 0.307684 | 1.14829 | 30 | 350ø-350ø | Level 2 | Level : Level 2 | 3.6 | Mechanical Supply Air 2
1111823 | 1DC1 | 566 | 0.328084 | 0.271794 | 0.656168 | 45.0001 | 200ø-200ø | Level 1 | Level : Level 1 | 2.94 | Mechanical Supply Air 1
570708 | 1D38 | 542 | 0.410105 | 0.339742 | 0.82021 | 45 | 250ø-250ø | Level 1 | Level : Level 1 | 3.41042 | Mechanical Supply Air 1
1121265 | 1D25 | 1155 | 0.328084 | 0.271794 | 0.656168 | 45 | 200ø-200ø | Level 1 | Level : Level 1 | 3.2 | Mechanical Supply Air 1 | CD3-17
570746 | 1C09 | 614 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Level 2 | Level : Level 2 | -1.07 | Mechanical Supply Air 1
570706 | 1D38 | 536 | 0.410105 | 0.339742 | 0.82021 | 45 | 250ø-250ø | Level 1 | Level : Level 1 | 3.69 | Mechanical Supply Air 1
571086 | 2D04 | 22 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Level 2 | Level : Level 2 | 3.6095 | Mechanical Supply Air 2 | CD3-11
1112864 | 1D25 | 657 | 0.328084 | 0.271794 | 0.656168 | 45 | 200ø-200ø | Level 1 | Level : Level 1 | 3.3 | Mechanical Supply Air 1 | CD3-17
570666 | 1A16 | 416 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Level 2 | Level : Level 2 | -0.8605 | Mechanical Supply Air 1 | CD3-11
1122735 | 1D37 | 1275 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Level 1 | Level : Level 1 | 3.3096 | Default Supply Air (cskender) | CD3-11
1119487 | 1C03 | 994 | 0.492126 | 0.407691 | 0.984252 | 45 | 300ø-300ø | Level 1 | Level : Level 1 | 3.7 | Mechanical Supply Air 1 | CD3-17
1122750 | 1D37 | 1283 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Level 1 | Level : Level 1 | 3.3096 | Default Supply Air (cskender) | CD3-11
1119665 | 1E09 | 1021 | 0.574147 | 0.476352 | 1.14829 | 45.0607 | 350ø-350ø | Level 1 | Level : Level 1 | 3.69357 | Mechanical Supply Air 1
1112794 | 1D25 | 653 | 0.328084 | 0.271794 | 0.656168 | 45 | 200ø-200ø | Level 1 | Level : Level 1 | 3.5 | Mechanical Supply Air 1 | CD3-17
570643 | 1D02 | 332 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Level 2 | Level : Level 2 | -0.8605 | Mechanical Supply Air 1 | CD3-11
1111820 | 1D20 | 563 | 0.328084 | 0.271791 | 0.656168 | 44.9997 | 200ø-200ø | Level 1 | Level : Level 1 | 3.20949 | Mechanical Supply Air 1
1111536 | 1DC1 | 498 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Level 1 | Level : Level 1 | 3.20948 | Mechanical Supply Air 1 | CD3-11
1111802 | 1DC1 | 555 | 0.328084 | 0.271797 | 0.656168 | 45.0004 | 200ø-200ø | Level 1 | Level : Level 1 | 3.20948 | Mechanical Supply Air 1
571099 | 2D04-A | 28 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Level 2 | Level : Level 2 | 3.6095 | Mechanical Supply Air 2 | CD3-11
1119473 | 1C03 | 978 | 0.492126 | 0.407691 | 0.984252 | 45 | 300ø-300ø | Level 1 | Level : Level 1 | 3.3 | Mechanical Supply Air 1 | CD3-17
1112862 | 1D25 | 655 | 0.328084 | 0.271794 | 0.656168 | 45 | 200ø-200ø | Level 1 | Level : Level 1 | 3.5 | Mechanical Supply Air 1 | CD3-17
570742 | 1C09 | 608 | 0.246063 | 0.203852 | 0.492126 | 45.0013 | 150ø-150ø | Level 2 | Level : Level 2 | -1.2105 | Mechanical Supply Air 1
1122077 | 2D10 | 1247 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Level 2 | Level : Level 2 | 3.4095 | Mechanical Supply Air 2 | CD3-11
570600 | 1A05 | 165 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Level 1 | Level : Level 1 | 3.7095 | Mechanical Supply Air 1 | CD3-11
1119655 | 1E09 | 1011 | 0.574147 | 0.4765 | 1.14829 | 45.0733 | 350ø-350ø | Level 1 | Level : Level 1 | 3.39457 | Mechanical Supply Air 1
570745 | 1CC2 | 612 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Level 1 | Level : Level 1 | 3.5 | Mechanical Supply Air 1 | CD3-11
570760 | 1D13 | 652 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Level 2 | Level : Level 2 | -1.27 | Mechanical Supply Air 1 | CD3-11
1120863 | 1DC6 | 1138 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Level 1 | Level : Level 1 | 3.2905 | Mechanical Supply Air 1 | CD3-11
570757 | 1D13 | 647 | 0.328084 | 0.271794 | 0.656168 | 45 | 200ø-200ø | Level 2 | Level : Level 2 | -1.0605 | Mechanical Supply Air 1 | CD3-17
570758 | 1D13 | 649 | 0.328084 | 0.271794 | 0.656168 | 45 | 200ø-200ø | Level 2 | Level : Level 2 | -1.27 | Mechanical Supply Air 1 | CD3-17
570644 | 1D02 | 334 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Level 2 | Level : Level 2 | -0.8605 | Mechanical Supply Air 1 | CD3-11
1100910 | 1D25 | 412 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Level 1 | Level : Level 1 | 3.3 | Mechanical Supply Air 1 | CD3-11

# IfcFlowFitting: Round Elbow - 1.5 D (3)
Type - ElementType: Round Elbow - 1.5 D
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Lining Thickness: 0; Insulation Thickness: 0; System Type: Supply Air; System Name: Mechanical Supply Air 1; Loss Method: 1
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Radius: 0.574147; Lining Radius: 0.574147; Insulation Radius: 0.574147; Center Radius: 1.72244; Size: 350ø-350ø
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Dimensions - Radius Multiplier: 1.5
Name (M_Round Elbow:Round Elbow - 1.5 D:Round Elbow - 1.5 D:...) | In | Level | Host | Offset (m) | Length1 | Angle (deg) | Mark
570712 | 1DC7 | Level 1 | Level : Level 1 | 3.3 | 0.461518 | 29.9994 | 548
570713 | Level 1 | Level 2 | Level : Level 2 | -0.88 | 0.461526 | 29.9999 | 550
570714 | 1D38 | Level 1 | Level : Level 1 | 3.69 | 0.713458 | 45 | 552 | PSet_Revit_Mechanical - ASHRAE Table: CD3-17

# IfcFlowFitting: Round Elbow - 2 D (4)
Type - ElementType: Round Elbow - 2 D
PSet_Revit_Mechanical - Lining Thickness: 0; Insulation Thickness: 0; System Type: Supply Air; System Name: Mechanical Supply Air 1; Loss Method: 1
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Level: Level 2; Host: Level : Level 2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Dimensions - Radius Multiplier: 2
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
Name (M_Round Elbow:Round Elbow - 2 D:Round Elbow - 2 D:...) | In | ASHRAE Table | Radius = Lining Radius = Insulation Radius | Length1 | Center Radius | Angle (deg) | Size | Mark | Offset (m)
570569 | 1A12 | CD3-17 | 0.246063 | 0.407691 | 0.984252 | 45 | 150ø-150ø | 94 | -1.07
570576 | 1A06 | CD3-17 | 0.328084 | 0.543587 | 1.31234 | 45 | 200ø-200ø | 111 | -1.26049
570575 | 1AC5 |  | 0.328084 | 0.543575 | 1.31234 | 44.9991 | 200ø-200ø | 107 | -0.869999
570571 | 1A12 | CD3-17 | 0.246063 | 0.407691 | 0.984252 | 45 | 150ø-150ø | 99 | -0.8355

# IfcFlowFitting: Round Takeoff (51)
Type - ElementType: Round Takeoff
PSet_Revit_Mechanical - Lining Thickness: 0; Insulation Thickness: 0; System Type: Supply Air; Loss Method: 1
PSet_Revit_Dimensions - Takeoff Fixed Length: 0.328084
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
Name (M_Round Takeoff:Round Takeoff:Round Takeoff:...) | In | System Name | Radius | Lining Diameter = Insulation Diameter = Diameter | Size | Takeoff Length Projection | Takeoff Length | Level | Host | Offset (m) | Mark
570737 | 1DC1 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.56986 | 587
571095 | 2D04-A | Mechanical Supply Air 2 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Roof - Main | Level : Roof - Main | -1.0705 | 26
570734 | 1DC1 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.56986 | 585
571082 | 2D04-A | Mechanical Supply Air 2 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Roof - Main | Level : Roof - Main | -1.0705 | 20
570716 | 1D36 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.185988 | 0.392448 | Level 2 | Level : Level 2 | -0.78 | 571
570752 | 1C05 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.3595 | 640
570723 | 1D40 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.3095 | 576
570749 | 1C04 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.3595 | 638
570728 | 1DC1 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.56986 | 580
570702 | 1D38 | Mechanical Supply Air 1 | 0.410105 | 0.82021 | 250ø-250ø | 0.430105 | 0.738189 | Level 1 | Level : Level 1 | 3.69 | 531
570731 | 1DC1 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.56986 | 582
1093659 | 1EC1 | Mechanical Supply Air 1 | 0.328084 | 0.656168 | 200ø-200ø | 0.158232 | 0.328084 | Level 1 | Level : Level 1 | 3.4 | 285
1099851 | 1C18 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.3095 | 393
570640 | 1D02 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 2 | Level : Level 2 | -0.8605 | 329
1122749 | 1D37 | Default Supply Air (cskender) | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.3096 | 1282
1125397 | 1BC3 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.2 | 1289
570597 | 1A05 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 2 | Level : Level 2 | -0.8605 | 163
998464 | 1C17 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.32809 | Level 1 | Level : Level 1 | 3.36986 | 153
1131964 | 1D16 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.3095 | 1297
1106781 | 1A16 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.3 | 453
998456 | 1C19 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.3095 | 145
1121268 | 1D25 | Mechanical Supply Air 1 | 0.328084 | 0.656168 | 200ø-200ø | 0.308084 | 0.328084 | Level 1 | Level : Level 1 | 3.2 | 1158
570550 | Level 1 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.0415277 | 0.349612 | Level 1 | Level : Level 1 | 3.4095 | 47
1111739 | 1DC1 | Mechanical Supply Air 1 | 0.410105 | 0.82021 | 250ø-250ø | 0.240093 | 0.32819 | Level 1 | Level : Level 1 | 3.2 | 549
998641 | 1D16 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.36986 | 183
1119986 | 1E16 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.3845 | 1051
1122080 | 2D10 | Mechanical Supply Air 2 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 2 | Level : Level 2 | 3.4095 | 1250
1119983 | 1E16 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.3845 | 1049
1115937 | 2C17 | Mechanical Supply Air 2 | 0.492126 | 0.984252 | 300ø-300ø | 0.02 | 0.328084 | Level 2 | Level : Level 2 | 3.40951 | 804
1119344 | 1D16 | Mechanical Supply Air 1 | 0.410105 | 0.82021 | 250ø-250ø | 0.240094 | 0.328084 | Level 1 | Level : Level 1 | 3.2 | 957
995205 | 1E16 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.4146 | 72
1122330 | 2CC1 | Mechanical Supply Air 2 | 0.328084 | 0.656168 | 200ø-200ø | 0.02 | 0.328084 | Level 2 | Level : Level 2 | 3.6095 | 1261
1120247 | 1D32 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.2905 | 1080
1122131 | 2D01 | Mechanical Supply Air 2 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 2 | Level : Level 2 | 3.60952 | 1252
1121409 | 1D06 | Mechanical Supply Air 1 | 0.328084 | 0.656168 | 200ø-200ø | 0.0200012 | 0.328085 | Level 1 | Level : Level 1 | 3.7095 | 1178
1119074 | 1D21 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.20948 | 909
1115861 | 2A01 | Mechanical Supply Air 2 | 0.410105 | 0.82021 | 250ø-250ø | 0.02 | 0.328084 | Level 2 | Level : Level 2 | 3.6095 | 786
1119305 | 1B14 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.3 | 944
1122492 | 2C03 | Mechanical Supply Air 2 | 0.328084 | 0.656168 | 200ø-200ø | 0.02 | 0.328084 | Level 2 | Level : Level 2 | 3.6095 | 1272
998624 | 1D16 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.36986 | 174
1119416 | 1C09 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.35948 | 974
1119302 | 1B12 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.3 | 939
1120862 | 1DC6 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.2905 | 1137
995276 | 1BC2 | Mechanical Supply Air 1 | 0.492126 | 0.984252 | 300ø-300ø | 0.184125 | 0.328084 | Level 1 | Level : Level 1 | 3.69 | 79
995648 | 1B19 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.6996 | 109
1120353 | 1C18 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.25 | 1098
1119243 | 1D16 | Mechanical Supply Air 1 | 0.328084 | 0.656168 | 200ø-200ø | 0.0200018 | 0.328086 | Level 1 | Level : Level 1 | 3.30951 | 930
1115250 | 2C19 | Mechanical Supply Air 2 | 0.328084 | 0.656168 | 200ø-200ø | 0.02 | 0.328084 | Level 2 | Level : Level 2 | 3.3595 | 743
998467 | 1C15 | Mechanical Supply Air 1 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 1 | Level : Level 1 | 3.3095 | 155
1122465 | 2A05 | Mechanical Supply Air 2 | 0.492126 | 0.984252 | 300ø-300ø | 0.02 | 0.328084 | Level 2 | Level : Level 2 | 3.6095 | 1268
995701 | 2C17 | Mechanical Supply Air 2 | 0.246063 | 0.492126 | 150ø-150ø | 0.02 | 0.328084 | Level 2 | Level : Level 2 | 3.4095 | 123

# IfcFlowFitting: Round Transition - 45 Degree (5)
Type - ElementType: Round Transition - 45 Degree
PSet_Revit_Dimensions - WidthOffsetfromBase: 10
PSet_Revit_Constraints - Level: Level 1; Host: Level : Level 1
PSet_Revit_Mechanical - Lining Thickness: 0; Insulation Thickness: 0; System Type: Supply Air; System Name: Mechanical Supply Air 1; Loss Method: 1
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Other - Num 4: 1; TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Constraints - Angle: 45 deg
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Round Transition - Angle:Round Transition - 45 Degree:Round Transition - 45 Degree:...) | In | Offest Delta | DiameterDelta | R1 = Lining Radius 1 = Insulation Radius 1 | R0 = Lining Radius 0 = Insulation Radius 0 = OffsetWidth | HeightOffsetfromBase | OffsetWidthTemp | OffsetHeightTemp | ComputedLength | Size | OffsetHeight | Offset (m) | ASHRAE Table | Mark | Num 5 | Num 3 | Num 2 | Num 1 | Length 2 | Length 1 | Length 3
570705 | 1D38 | 0 | 0.164042 | 0.410105 | 0.574147 | 10 | 0.0478456 | 0.0478456 | 0.396032 | 350ø-250ø | 0.574147 | 3.69 | SD4-1 | 535 | 4.75239 | 3.93701 | 1.9685 | 1.9685 | 0.164042 | 0.164042 | 0
1121202 | 1D25 | 0.296916 | 0 | 0.328084 | 0.328084 | 9.70308 | 0.0273403 | 0.0520833 | 0.164042 | 200ø-200ø | 0.625 | 3.2 |  | 1148 | 0 | 0 | 0 | 0 | 0 | 0 | 0
570665 | 1A16 | 0 | 0.082021 | 0.246063 | 0.328084 | 10 | 0.0273403 | 0.0273403 | 0.198016 | 200ø-150ø | 0.328084 | 3.49914 | SD4-1 | 415 | 2.37619 | 1.9685 | 0.984252 | 0.984252 | 0.082021 | 0.082021 | 2.84217e-14
1112951 | 1D25 | 0 | 0.082021 | 0.246063 | 0.328084 | 10 | 0.0273403 | 0.0273403 | 0.198016 | 200ø-150ø | 0.328084 | 3.3 | SD4-1 | 659 | 2.37619 | 1.9685 | 0.984252 | 0.984252 | 0.082021 | 0.082021 | 0
1121613 | 1B03 | -2.84217e-14 | 0 | 0.492126 | 0.492126 | 10.3281 | 0.0410105 | 0.0136702 | 0.246063 | 300ø-300ø | 0.164042 | 3.79 |  | 1197 | 0 | 0 | -3.41061e-13 | 3.41061e-13 | -2.84217e-14 | 2.84217e-14 | 2.84217e-14

# IfcFlowFitting: Standard (800)
Type - ElementType: Standard
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Lining Thickness: 0; Insulation Thickness: 0; Loss Method: 1
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name | In | Level | Host | Offset (m) | Lining Width = Insulation Width | Lining Height = Insulation Height | Size | System Type | System Name | Mark | Takeoff Fixed Length | Takeoff Length Projection | Takeoff Length
M_Rectangular Elbow - Mitered:Standard:Standard:566712 | 1D13 | Level 2 | Level : Level 2 | -0.93 | 3.77297 | 1.31234 | 1150x400-1150x400 | Return Air | Mechanical Return Air 1 | 42 | PSet_Revit_Dimensions - Width: 3.77297; Length1: 1.9685; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:567503 | 1BC2 | Level 1 | Level : Level 1 | 3.37 | 0.656168 | 0.492126 | 200x150-200x150 | Supply Air | Mechanical Supply Air 1 | 2281 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567295 | 1BC4 | Level 1 | Level : Level 1 | 3.715 | 0.984252 | 3.28084 | 300x1000-300x1000 | Return Air | Mechanical Return Air 1 | 1575 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.285866; Height: 3.28084; Angle: 45 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:567264 | 1B17 | Level 1 | Level : Level 1 | 3.3 | 2.13255 | 0.656168 | 650x200-650x200 | Return Air | Mechanical Return Air 1 | 1495 | PSet_Revit_Dimensions - Width: 2.13255; Length1: 0.523686; Height: 0.656168; Angle: 45 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:567345 | 1BC4 | Level 1 | Level : Level 1 | 3.3 | 0.984252 | 0.492126 | 300x150-300x150 | Supply Air | Mechanical Supply Air 1 | 1755 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569929 | 2D14 | Roof - Main | Level : Roof - Main | -0.78 | 1.9685 | 1.14829 | 600x350-600x350 | Return Air | Mechanical Return Air 2 | 8234 | PSet_Revit_Dimensions - Width: 1.9685; Length1: 1.06627; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569482 | 2AC1 | Roof - Main | Level : Roof - Main | -1.0705 | 0.82021 | 0.82021 | 250x250-250x250 | Supply Air | Default Supply Air (cskender) | 7049 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567189 | 1D16 | Level 1 | Level : Level 1 | 3.64 | 1.47638 | 0.82021 | 450x250-450x250 | Return Air | Mechanical Return Air 1 | 1405 | PSet_Revit_Dimensions - Width: 1.47638; Length1: 0.82021; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570004 | 2D09 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8388 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569428 | 2A04 | Roof - Main | Level : Roof - Main | -1.0705 | 0.492126 | 0.984252 | 150x300-150x300 | Supply Air | Mechanical Supply Air 2 | 6859 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566988 | 1E22 | Level 2 | Level : Level 2 | -0.755 | 0.656168 | 0.492126 | 200x150-200x150 | Return Air | Mechanical Return Air 1 | 986 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569989 | 2D18 | Level 2 | Level : Level 2 | 4 | 0.984252 | 0.984252 | 300x300-300x300 | Return Air | Mechanical Return Air 2 | 8369 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567361 | 1BC4 | Level 1 | Level : Level 1 | 3.3 | 0.328084 | 0.82021 | 100x250-100x250 | Supply Air | Mechanical Supply Air 1 | 1778 | PSet_Revit_Dimensions - Width: 0.328084; Length1: 0.246063; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567183 | 1D16 | Level 1 | Level : Level 1 | 3.64 | 1.47638 | 0.82021 | 450x250-450x250 | Return Air | Mechanical Return Air 1 | 1397 | PSet_Revit_Dimensions - Width: 1.47638; Length1: 0.82021; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:569957 | 2D19 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8323 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567360 | 1BC4 | Level 1 | Level : Level 1 | 3.3 | 0.82021 | 0.328084 | 250x100-250x100 | Supply Air | Mechanical Supply Air 1 | 1777 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 0.328084; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567296 | 1BC4 | Level 1 | Level : Level 1 | 3.3 | 0.984252 | 3.28084 | 300x1000-300x1000 | Return Air | Mechanical Return Air 1 | 1581 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.285866; Height: 3.28084; Angle: 45 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:569939 | 2D19 | Roof - Main | Level : Roof - Main | -0.78 | 1.47638 | 0.82021 | 450x250-450x250 | Return Air | Mechanical Return Air 2 | 8285 | PSet_Revit_Dimensions - Width: 1.47638; Length1: 0.82021; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566984 | 1E16 | Level 1 | Level : Level 1 | 3.815 | 0.984252 | 0.984252 | 300x300-300x300 | Return Air | Mechanical Return Air 1 | 980 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566989 | 1E22 | Level 1 | Level : Level 1 | 3.815 | 0.492126 | 0.656168 | 150x200-150x200 | Return Air | Mechanical Return Air 1 | 987 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.656168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569358 | 2C10 | Level 2 | Level : Level 2 | 3.6095 | 0.492126 | 1.31234 | 150x400-150x400 | Supply Air | Mechanical Supply Air 2 | 6735 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328075; Height: 1.31234; Angle: 89.9979 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569983 | 2D16 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8359 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568282 | 1D10 | Level 2 | Level : Level 2 | -0.86052 | 0.656168 | 0.82021 | 200x250-200x250 | Supply Air | Mechanical Supply Air 1 | 4809 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568325 | 1C07 | Level 2 | Level : Level 2 | -0.860523 | 0.656168 | 0.656168 | 200x200-200x200 | Supply Air | Mechanical Supply Air 1 | 4956 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 0.656168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569194 | 2C16 | Level 2 | Level : Level 2 | 3.40948 | 0.656168 | 1.31234 | 200x400-200x400 | Supply Air | Mechanical Supply Air 2 | 6223 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569622 | 2B19 | Roof - Main | Level : Roof - Main | -1.0705 | 0.656168 | 0.82021 | 200x250-200x250 | Supply Air | Mechanical Supply Air 2 | 7454 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566953 | 1C09 | Level 1 | Level : Level 1 | 3.64 | 1.14829 | 0.656168 | 350x200-350x200 | Return Air | Mechanical Return Air 1 | 917 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.656168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568292 | 1D07 | Level 2 | Level : Level 2 | -0.860518 | 0.82021 | 0.82021 | 250x250-250x250 | Supply Air | Mechanical Supply Air 1 | 4837 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569335 | 2C03 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.47638 | 150x450-150x450 | Return Air | Mechanical Return Air 2 | 6648 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.47638; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568460 | 1C08 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 1 | 5259 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567048 | 1D30 | Level 1 | Level : Level 1 | 3.64 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 1 | 1083 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569953 | 2D20 | Roof - Main | Level : Roof - Main | -0.68 | 1.80446 | 0.656168 | 550x200-550x200 | Return Air | Mechanical Return Air 2 | 8321 | PSet_Revit_Dimensions - Width: 1.80446; Length1: 0.984252; Height: 0.656168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570186 | 2D04 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.31234 | 150x400-150x400 | Return Air | Mechanical Return Air 2 | 8702 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
