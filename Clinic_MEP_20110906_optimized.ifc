Properties of the parts of a building model (IFC2X3), part 290 of 295

# IfcFlowTerminal: 0600x1200mm(2 Lamp) - 120V (439)
PSet_Revit_Type_Materials and Finishes - Light Box Material: Metal - Chrome; Grid Material: Metal - Paint Finish - Dark Gray, Matte; Diffuser Material: Glass - White, High Luminance
Name (M_Troffer Light - Parabolic Rectangular:0600x1200mm(2 Lamp) - 120V:0600x1200mm(2 Lamp) - 120V:...) | In | Schedule Level | TagNumber | Panel | Circuit Number | Host | Mark
737660 | 1B06 | Level 1 | B1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | B1
738931 | 1D30 | Level 1 | B1 | L41B | 4 | <not associated> | B1
740326 | 1E24 | Level 1 | B1 | L41B | 7 | <not associated> | B1
741352 | 1D05 | Level 1 | C18 | N21C1 | 24 | <not associated> | C18
738921 | 1D31 | Level 1 | B1 | L41B | 4 | <not associated> | B1
740334 | 1E24 | Level 1 | B1B | L41B | 7 | <not associated> | B1B
738199 | 1B08 | Level 1 | B1 | L41B | 1 | <not associated> | B1
739015 | 1D23 | Level 1 | B1 | L41B | 5 | <not associated> | B1
739270 | 1D06 | Level 1 | C18 | N21C1 | 24 | <not associated> | C18
740164 | 1E18 | Level 1 | B1 | L41B | 6 | <not associated> | B1
740368 | 1E25 | Level 1 | C1 | L41B | 7 | <not associated> | C1
783980 | 2A10 | Level 2 | B1 | L42C | 7 | Linked Revit Model : Clinic_A.rvt | B1
740172 | 1E18 | Level 1 | B1 | L41B | 6 | <not associated> | B1
740360 | 1E25 | Level 1 | C1 | L41B | 7 | <not associated> | C1
738276 | 1B04 | Level 1 | B1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | B1
737678 | 1B06 | Level 1 | B1 | L41B | 1 | <not associated> | B1
738264 | 1B04 | Level 1 | B1B | L41B | 1 | Linked Revit Model : Clinic_A.rvt | B1B
738653 | 1E11 | Level 1 | B1 | L41B | 3 | <not associated> | B1
740439 | 1E29 | Level 1 | B1 | L41B | 7 | <not associated> | B1
741104 | 1C08 | Level 1 | B1D | L41C | 9 | <not associated> | B1D
738903 | 1D33 | Level 1 | B1 | L41B | 4 | <not associated> | B1
741128 | 1C04 | Level 1 | C1 | L41C | 9 | <not associated> | C1
739262 | 1D06 | Level 1 | C18 | N21C1 | 24 | <not associated> | C18
826140 | 1E07 | Level 1 | B1 | L41B | 3 | <not associated> | B1
738254 | 1B04 | Level 1 | B1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | B1
739202 | 1D12 | Level 1 | B18 | L41C | 3 | <not associated> | B18
738239 | 1B10 | Level 1 | B1 | L41B | 1 | <not associated> | B1
757176 | 2C14 | Level 2 | A3 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | A3
738255 | 1B04 | Level 1 | B1 | L41B | 1 | <not associated> | B1
738286 | 1B04 | Level 1 | B1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | B1
740523 | 1E28 | Level 1 | B1 | L41B | 7 | <not associated> | B1
739522 | 1C18 | Level 1 | C18 | L41C | 4 | <not associated> | C18
771736 | 2B18 | Level 2 | B1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | B1
739761 | 1A16 | Level 1 | A2B | N21C1 | 24 | <not associated> | A2B
738991 | 1D24 | Level 1 | B1 | L41B | 5 | <not associated> | B1
739007 | 1D23 | Level 1 | B1 | L41B | 5 | <not associated> | B1
741008 | 1B13 | Level 1 | B1 | L41B | 1 | <not associated> | B1
759607 | 2A06 | Level 2 | A3 | L42C | 8 | Linked Revit Model : Clinic_A.rvt | A3
741090 | 1C09 | Level 1 | B1D | L41C | 9 | <not associated> | B1D
757939 | 2C09 | Level 2 | A3 | L42C | 5 | Linked Revit Model : Clinic_A.rvt | A3
740152 | 1E16 | Level 1 | B1 | L41B | 6 | <not associated> | B1
738788 | 1D25 | Level 1 | B1 | L41B | 5 | <not associated> | B1
741172 | 1D02 | Level 1 | C18 | L41C | 3 | <not associated> | C18
739769 | 1AC4 | Level 1 | A2 | N21C1 | 24 | <not associated> | A2
771351 | 2D21 | Level 2 | B1 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | B1
738913 | 1D31 | Level 1 | B1 | L41B | 4 | <not associated> | B1
738583 | 1D34 | Level 1 | C18 | L41B | 4 | <not associated> | C18
739108 | 1D22 | Level 1 | B1 | L41C | 5 | <not associated> | B1
738820 | 1D25 | Level 1 | B1 | L41B | 5 | <not associated> | B1
738197 | 1B08 | Level 1 | B1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | B1
771155 | 2D21 | Level 2 | B1 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | B1
740188 | 1E30 | Level 1 | B1 | L41B | 6 | <not associated> | B1
757290 | 2C14 | Level 2 | A3 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | A3
739244 | 1D08 | Level 1 | C18 | L41C | 3 | <not associated> | C18
771103 | 2D21 | Level 2 | B1 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | B1
826172 | 1E07 | Level 1 | B1 | L41B | 3 | <not associated> | B1
738965 | 1D27 | Level 1 | B1 | L41B | 5 | <not associated> | B1
739041 | 1D25 | Level 1 | B1 | L41B | 5 | <not associated> | B1
741118 | 1C04 | Level 1 | C1 | L41C | 9 | <not associated> | C1
740467 | 1E26 | Level 1 | B1B | L41B | 7 | <not associated> | B1B
740515 | 1E28 | Level 1 | B1 | L41B | 7 | <not associated> | B1
739254 | 1D05 | Level 1 | C18 | N21C1 | 24 | <not associated> | C18
740742 | 1A01 | Level 1 | A2 | L41C | 1 | <not associated> | A2
758566 | 2C04 | Level 2 | A3 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | A3
740142 | 1E16 | Level 1 | B1 | L41B | 6 | <not associated> | B1
739360 | 1D13 | Level 1 | C18 | L41C | 3 | <not associated> | C18
739574 | 1C18 | Level 1 | C18 | L41C | 4 | <not associated> | C18
739514 | 1C18 | Level 1 | C18 | L41C | 4 | <not associated> | C18
740572 | 1A02 | Level 1 | A2 | L41C | 1 | <not associated> | A2
739542 | 1C18 | Level 1 | C18 | L41C | 4 | <not associated> | C18
740770 | 1A08 | Level 1 | B1 | N21C1 | 23 | <not associated> | B1
758137 | 2C09 | Level 2 | A3 | L42C | 5 | Linked Revit Model : Clinic_A.rvt | A3
739182 | 1D18 | Level 1 | B1 | L41C | 5 | <not associated> | B1
740505 | 1E27 | Level 1 | B1 | L41B | 7 | <not associated> | B1
758214 | 2C06 | Level 2 | A3 | L42C | 5 | <not associated> | A3
743160 | 1C19 | Level 1 | B18 | L41C | 4 | <not associated> | B18
739236 | 1D08 | Level 1 | C18 | L41C | 3 | <not associated> | C18
738999 | 1D23 | Level 1 | B1 | L41B | 5 | <not associated> | B1
739076 | 1D25 | Level 1 | B1 | L41B | 5 | <not associated> | B1
741042 | 1B15 | Level 1 | C1D | L41B | 1 | <not associated> | C1D
739442 | 1D16 | Level 1 | B1 | L41C | 5 | <not associated> | B1
740475 | 1E26 | Level 1 | B1 | L41B | 7 | <not associated> | B1
739192 | 1D15 | Level 1 | B1 | L41C | 3 | <not associated> | B1
741278 | 1D02 | Level 1 | C18 | L41C | 3 | <not associated> | C18
738776 | 1D25 | Level 1 | B1 | L41B | 5 | <not associated> | B1
738265 | 1B04 | Level 1 | B1 | L41B | 1 | <not associated> | B1
826180 | 1E07 | Level 1 | B1 | L41B | 3 | <not associated> | B1
739023 | 1D23 | Level 1 | B1 | L41B | 5 | <not associated> | B1
759797 | 2A05 | Level 2 | A3 | L42C | 8 | Linked Revit Model : Clinic_A.rvt | A3
771279 | 2D21 | Level 2 | B1 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | B1
738828 | 1D25 | Level 1 | B1 | L41B | 5 | <not associated> | B1
739220 | 1D10 | Level 1 | C18 | L41C | 3 | <not associated> | C18
739400 | 1D16 | Level 1 | B1 | L41C | 5 | <not associated> | B1
738939 | 1D30 | Level 1 | B1 | L41B | 4 | <not associated> | B1
783989 | 2A10 | Level 2 | B1 | L42C | 7 | Linked Revit Model : Clinic_A.rvt | B1
740300 | 1E24 | Level 1 | B1 | L41B | 7 | <not associated> | B1
758065 | 2C09 | Level 2 | A3 | L42C | 5 | <not associated> | A3
756954 | 2C16 | Level 2 | A2B | L42C | 1 | Linked Revit Model : Clinic_A.rvt | A2B
738419 | 1E05 | Level 1 | B1 | L41B | 3 | <not associated> | B1
738277 | 1B04 | Level 1 | B1 | L41B | 1 | <not associated> | B1
741098 | 1C08 | Level 1 | B1D | L41C | 9 | <not associated> | B1D
739891 | 1A05 | Level 1 | B1 | L41C | 1 | <not associated> | B1
739124 | 1D21 | Level 1 | B1 | L41C | 5 | <not associated> | B1
740780 | 1A09 | Level 1 | B1 | N21C1 | 23 | <not associated> | B1
738539 | 1E08 | Level 1 | F1 | L41B | 3 | <not associated> | F1
759747 | 2A05 | Level 2 | A3 | L42C | 8 | Linked Revit Model : Clinic_A.rvt | A3
740696 | 1AC5 | Level 1 | A2 | L41C | 1 | <not associated> | A2
771897 | 2B21 | Level 2 | B1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | B1
738635 | 1D28 | Level 1 | C18 | L41B | 4 | <not associated> | C18
759666 | 2A05 | Level 2 | A3 | L42C | 8 | Linked Revit Model : Clinic_A.rvt | A3
772036 | 2B23 | Level 2 | B1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | B1
739228 | 1D10 | Level 1 | C18 | L41C | 3 | <not associated> | C18
738895 | 1D33 | Level 1 | B1 | L41B | 4 | <not associated> | B1
738567 | 1D36 | Level 1 | C18 | L41B | 4 | <not associated> | C18
740206 | 1E24 | Level 1 | B1 | L41B | 7 | <not associated> | B1
739707 | 1C05 | Level 1 | C1D | L41C | 9 | <not associated> | C1D
739743 | 1A16 | Level 1 | A2B | N21C1 | 24 | <not associated> | A2B
740497 | 1E26 | Level 1 | B1 | L41B | 7 | <not associated> | B1
739132 | 1D21 | Level 1 | B1 | L41C | 5 | <not associated> | B1
739408 | 1D16 | Level 1 | B1 | L41C | 5 | <not associated> | B1
738287 | 1B04 | Level 1 | B1B | L41B | 1 | <not associated> | B1B
769575 | 2D11 | Level 2 | B1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | B1
758632 | 2C04 | Level 2 | A3 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | A3
738981 | 1D24 | Level 1 | B1 | L41B | 5 | <not associated> | B1
741014 | 1B13 | Level 1 | B1 | L41B | 1 | <not associated> | B1
739116 | 1D21 | Level 1 | B1 | L41C | 5 | <not associated> | B1
771219 | 2D21 | Level 2 | B1 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | B1
741344 | 1D05 | Level 1 | C18B | N21C1 | 24 | <not associated> | C18B
739530 | 1C18 | Level 1 | C18B | L41C | 4 | <not associated> | C18B
758668 | 2C02 | Level 2 | A3 | L42C | 4 | <not associated> | A3
739480 | 1C15 | Level 1 | C1 | N21C1 | 22 | <not associated> | C1
771695 | 2B18 | Level 2 | B1 | L42B | 1 | <not associated> | B1
739725 | 1A10 | Level 1 | B1 | N21C1 | 23 | <not associated> | B1
739468 | 1D16 | Level 1 | B1 | L41C | 5 | <not associated> | B1
738238 | 1B10 | Level 1 | B1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | B1
740440 | 1E29 | Level 1 | B1 | L41B | 7 | <not associated> | B1
739663 | 1C16 | Level 1 | B18 | L41C | 4 | <not associated> | B18
757603 | 2C11 | Level 2 | C1 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | C1
740198 | 1E24 | Level 1 | B1 | L41B | 7 | <not associated> | B1
738625 | 1D32 | Level 1 | C18 | L41B | 4 | <not associated> | C18
738575 | 1D34 | Level 1 | C18 | L41B | 4 | <not associated> | C18
759928 | 2A04 | Level 2 | B1 | L42C | 6 | Linked Revit Model : Clinic_A.rvt | B1
740318 | 1E24 | Level 1 | B1 | L41B | 7 | <not associated> | B1
738973 | 1D27 | Level 1 | B1 | L41B | 5 | <not associated> | B1
767463 | 2D04 | Level 2 | B1 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | B1
739699 | 1C05 | Level 1 | C1D | L41C | 9 | <not associated> | C1D
739460 | 1D16 | Level 1 | B1 | L41C | 5 | <not associated> | B1
738555 | 1D36 | Level 1 | C18 | L41B | 4 | <not associated> | C18
739372 | 1D16 | Level 1 | B1 | L41C | 5 | <not associated> | B1
757212 | 2C14 | Level 2 | A3 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | A3
738810 | 1D25 | Level 1 | B1 | L41B | 5 | <not associated> | B1
771838 | 2B21 | Level 2 | B1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | B1
740180 | 1E18 | Level 1 | B1 | L41B | 6 | <not associated> | B1
757047 | 2C14 | Level 2 | A3 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | A3
757334 | 2C13 | Level 2 | B1 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | B1
739496 | 1C15 | Level 1 | C1 | N21C1 | 22 | <not associated> | C1
739671 | 1C19 | Level 1 | B18 | L41C | 4 | <not associated> | B18
740485 | 1E26 | Level 1 | B1 | L41B | 7 | <not associated> | B1
741068 | 1B01 | Level 1 | B1 | L41B | 1 | <not associated> | B1
767999 | 2D04-A | Level 2 | B1 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | B1
740128 | 1E16 | Level 1 | B1 | L41B | 6 | <not associated> | B1
758823 | 2A09 | Level 2 | A3 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | A3
738713 | 1E14 | Level 1 | B1 | L41B | 5 | <not associated> | B1
740788 | 1A12 | Level 1 | B1 | N21C1 | 23 | <not associated> | B1
771644 | 2B16 | Level 2 | B1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | B1
740992 | 1B13 | Level 1 | B1 | L41B | 1 | <not associated> | B1
741084 | 1C09 | Level 1 | B1D | L41C | 9 | <not associated> | B1D
758349 | 2C06 | Level 2 | A3 | L42C | 5 | Linked Revit Model : Clinic_A.rvt | A3
772786 | 2B17 | Level 2 | C1 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | C1
767959 | 2D04-A | Level 2 | B1 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | B1
739158 | 1D20 | Level 1 | B1 | L41C | 5 | <not associated> | B1
770158 | 2D14 | Level 2 | B1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | B1
740134 | 1E16 | Level 1 | B1B | L41B | 6 | <not associated> | B1B
741000 | 1B13 | Level 1 | B1 | L41B | 1 | <not associated> | B1
759447 | 2A06 | Level 2 | A3 | L42C | 8 | Linked Revit Model : Clinic_A.rvt | A3
758406 | 2C06 | Level 2 | A3 | L42C | 5 | Linked Revit Model : Clinic_A.rvt | A3
739140 | 1D21 | Level 1 | B1 | L41C | 5 | <not associated> | B1
738643 | 1D28 | Level 1 | C18 | L41B | 4 | <not associated> | C18
739777 | 1A16 | Level 1 | A2 | N21C1 | 24 | <not associated> | A2
740714 | 1AC5 | Level 1 | A2 | L41C | 1 | <not associated> | A2
739797 | 1A16 | Level 1 | A2 | N21C1 | 24 | <not associated> | A2
738695 | 1E14 | Level 1 | B1 | L41B | 5 | <not associated> | B1
739098 | 1D22 | Level 1 | B1B | L41C | 5 | <not associated> | B1B
738885 | 1D35 | Level 1 | B1 | L41B | 4 | <not associated> | B1
739210 | 1D12 | Level 1 | B18 | L41C | 3 | <not associated> | B18
761434 | 2A11 | Level 2 | B1B | L42C | 7 | Linked Revit Model : Clinic_A.rvt | B1B
740982 | 1B17 | Level 1 | B1 | L41B | 1 | <not associated> | B1
767557 | 2D04 | Level 2 | B1B | L42B | 2 | Linked Revit Model : Clinic_A.rvt | B1B
739174 | 1D19 | Level 1 | B1 | L41C | 5 | <not associated> | B1
740860 | 1D40 | Level 1 | A28 | L41B | 4 | <not associated> | A2B
767247 | 2D03 | Level 2 | B1 | L42B | 2 | <not associated> | B1
740214 | 1E24 | Level 1 | B1B | L41B | 7 | <not associated> | B1B
738483 | 1E05 | Level 1 | B1 | L41B | 3 | <not associated> | B1
758706 | 2C02 | Level 2 | A3 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | A3
739919 | 1A04 | Level 1 | B1 | L41C | 1 | <not associated> | B1
739488 | 1C15 | Level 1 | C1 | N21C1 | 22 | <not associated> | C1
739380 | 1D16 | Level 1 | B1 | L41C | 5 | <not associated> | B1
739304 | 1D09 | Level 1 | C18 | L41C | 3 | <not associated> | C18
740762 | 1A08 | Level 1 | B1 | N21C1 | 23 | <not associated> | B1
758020 | 2C09 | Level 2 | A3 | L42C | 5 | Linked Revit Model : Clinic_A.rvt | A3
739033 | 1D25 | Level 1 | B1 | L41B | 5 | <not associated> | B1
739342 | 1D11 | Level 1 | C18 | L41C | 3 | <not associated> | C18
740282 | 1E24 | Level 1 | B1 | L41B | 7 | <not associated> | B1
770241 | 2D15 | Level 2 | B1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | B1
772866 | 2B15 | Level 2 | C1 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | C1
739715 | 1A10 | Level 1 | B1 | N21C1 | 23 | <not associated> | B1
740798 | 1C07 | Level 1 | B18 | N21C1 | 22 | <not associated> | B18
739090 | 1D22 | Level 1 | B1 | L41C | 5 | <not associated> | B1
739783 | 1A16 | Level 1 | A2 | N21C1 | 24 | <not associated> | A2
739550 | 1C18 | Level 1 | C18 | L41C | 4 | <not associated> | C18
739691 | 1C06 | Level 1 | B1 | L41C | 9 | <not associated> | B1
738877 | 1D35 | Level 1 | B1 | L41B | 4 | <not associated> | B1
739791 | 1A16 | Level 1 | A2 | N21C1 | 24 | <not associated> | A2
741074 | 1B01 | Level 1 | B1 | L41B | 1 | <not associated> | B1
740102 | 1E16 | Level 1 | B1 | L41B | 6 | <not associated> | B1
772961 | 2B15 | Level 2 | C1 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | C1
738729 | 1D25 | Level 1 | B1 | L41B | 5 | <not associated> | B1
756865 | 2C16 | Level 2 | A2B | L42C | 1 | Linked Revit Model : Clinic_A.rvt | A2B
773095 | 2B14 | Level 2 | B1 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | B1
773998 | 2C23 | Level 2 | B1B | L42C | 2 | Linked Revit Model : Clinic_A.rvt | B1B
740310 | 1E24 | Level 1 | B1 | L41B | 7 | <not associated> | B1
758595 | 2C04 | Level 2 | A3 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | A3
738491 | 1E06 | Level 1 | B1 | L41B | 3 | <not associated> | B1
759249 | 2A07 | Level 2 | A3 | L42C | 8 | Linked Revit Model : Clinic_A.rvt | A3
739280 | 1D07 | Level 1 | C18 | L41C | 3 | <not associated> | C18
739879 | 1A03 | Level 1 | B1 | L41C | 1 | <not associated> | B1
739629 | 1C18 | Level 1 | C18B | L41C | 4 | <not associated> | C18B
739506 | 1C18 | Level 1 | C18 | L41C | 4 | <not associated> | C18
770554 | 2D19 | Level 2 | B1 | L42B | 6 | <not associated> | B1
769304 | 2D10 | Level 2 | C1B | L42B | 6 | Linked Revit Model : Clinic_A.rvt | C1B
772734 | 2B19 | Level 2 | B1 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | B1
770646 | 2D19 | Level 2 | B1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | B1
739911 | 1A04 | Level 1 | B1 | L41C | 1 | <not associated> | B1
739655 | 1C16 | Level 1 | B18 | L41C | 4 | <not associated> | B18
739823 | 1A16 | Level 1 | A2 | N21C1 | 24 | <not associated> | A2
826190 | 1E07 | Level 1 | B1 | L41B | 3 | <not associated> | B1
738383 | 1B04 | Level 1 | B1 | L41B | 1 | <not associated> | B1
740120 | 1E16 | Level 1 | B1 | L41B | 6 | <not associated> | B1
770900 | 2D20 | Level 2 | B1 | L42B | 7 | Linked Revit Model : Clinic_A.rvt | B1
759356 | 2A06 | Level 2 | A3 | L42C | 8 | Linked Revit Model : Clinic_A.rvt | A3
761620 | 2A11 | Level 2 | B1 | L42C | 7 | <not associated> | B1
739901 | 1A05 | Level 1 | B1 | L41C | 1 | <not associated> | B1
767675 | 2D01 | Level 2 | B1 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | B1
741034 | 1B13 | Level 1 | B1 | L41B | 1 | <not associated> | B1
739434 | 1D16 | Level 1 | B1 | L41C | 5 | <not associated> | B1
740706 | 1A02 | Level 1 | A2 | L41C | 1 | <not associated> | A2
739312 | 1D09 | Level 1 | C18 | L41C | 3 | <not associated> | C18
740724 | 1A02 | Level 1 | A2 | L41C | 1 | <not associated> | A2
772330 | 2B01 | Level 2 | B1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | B1
738800 | 1D25 | Level 1 | B1 | L41B | 5 | <not associated> | B1
769664 | 2D16 | Level 2 | B1 | L42B | 6 | <not associated> | B1
739871 | 1A03 | Level 1 | B1 | L41C | 1 | <not associated> | B1
759855 | 2A05 | Level 2 | A3 | L42C | 8 | Linked Revit Model : Clinic_A.rvt | A3
770065 | 2D14 | Level 2 | B1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | B1
740090 | 1E16 | Level 1 | B1 | L41B | 6 | <not associated> | B1
738547 | 1E08 | Level 1 | B1 | L41B | 3 | <not associated> | B1
766836 | 2B7 | Level 2 | B1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | B1
740732 | 1AC5 | Level 1 | A2B | L41C | 1 | <not associated> | A2B
738661 | 1E11 | Level 1 | B1 | L41B | 3 | <not associated> | B1
766726 | 2B4 | Level 2 | C1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | C1
767010 | 2B9 | Level 2 | B1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | B1
740236 | 1E24 | Level 1 | B1 | L41B | 7 | <not associated> | B1
741052 | 1B03 | Level 1 | C1 | L41B | 1 | <not associated> | C1
739751 | 1A16 | Level 1 | A2 | N21C1 | 24 | <not associated> | A2
772253 | 2B01 | Level 2 | B1 | L42B | 1 | <not associated> | B1
740750 | 1A01 | Level 1 | A2 | L41C | 1 | <not associated> | A2
738409 | 1D38 | Level 1 | C18B | L41B | 4 | <not associated> | C18B
738499 | 1E06 | Level 1 | B1 | L41B | 3 | <not associated> | B1
739813 | 1A16 | Level 1 | A2 | N21C1 | 24 | <not associated> | A2
740112 | 1E16 | Level 1 | B1 | L41B | 6 | <not associated> | B1
762032 | 2A14 | Level 2 | B1 | L42C | 7 | Linked Revit Model : Clinic_A.rvt | B1
771988 | 2B23 | Level 2 | B1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | B1
739388 | 1D16 | Level 1 | B1B | L41C | 5 | <not associated> | B1B
770937 | 2D21 | Level 2 | B1 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | B1
769040 | 2D06 | Level 2 | B1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | B1
739352 | 1D13 | Level 1 | C18 | L41C | 3 | <not associated> | C18
741060 | 1B03 | Level 1 | C1B | L41B | 1 | <not associated> | C1B
738615 | 1D32 | Level 1 | C18 | L41B | 4 | <not associated> | C18
772157 | 2B24 | Level 2 | B1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | B1
740844 | 1D40 | Level 1 | A28 | L41B | 4 | <not associated> | A2B
740806 | 1C07 | Level 1 | B18 | N21C1 | 22 | <not associated> | B18
761518 | 2A11 | Level 2 | B1 | L42C | 7 | <not associated> | B1
772665 | 2B19 | Level 2 | B1 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | B1
768636 | 2D08 | Level 2 | B1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | B1
739849 | 1A15 | Level 1 | B1 | N21C1 | 24 | <not associated> | B1
739639 | 1C14 | Level 1 | B1 | L41C | 4 | <not associated> | B1
739735 | 1A16 | Level 1 | A2 | N21C1 | 24 | <not associated> | A2
740974 | 1B17 | Level 1 | B1B | L41B | 1 | <not associated> | B1B
767811 | 2D02 | Level 2 | B1 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | B1
740852 | 1D40 | Level 1 | A28 | L41B | 4 | <not associated> | A2B
740082 | 1E16 | Level 1 | B1B | L41B | 6 | <not associated> | B1B
770454 | 2D17 | Level 2 | B1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | B1
740824 | 1C10 | Level 1 | B18 | N21C1 | 22 | <not associated> | B18
758854 | 2A09 | Level 2 | A3 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | A3
773329 | 2B10 | Level 2 | B1 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | B1
767896 | 2D04-A | Level 2 | B1 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | B1
740244 | 1E24 | Level 1 | B1 | L41B | 7 | <not associated> | B1
759535 | 2A06 | Level 2 | A3 | L42C | 8 | Linked Revit Model : Clinic_A.rvt | A3
769225 | 2D10 | Level 2 | C1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | C1
773871 | 2C24 | Level 2 | B1B | L42C | 2 | Linked Revit Model : Clinic_A.rvt | B1B
759055 | 2A08 | Level 2 | A3 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | A3
758485 | 2C06 | Level 2 | A3 | L42C | 5 | Linked Revit Model : Clinic_A.rvt | A3
763552 | 2C10 | Level 2 | A2 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | A2
743971 | 1C17 | Level 1 | B1 | L41C | 4 | <not associated> | B1
758695 | 2C02 | Level 2 | A3 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | A3
766551 | 2B3 | Level 2 | B1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | B1
758733 | 2A09 | Level 2 | A3 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | A3
767412 | 2D04 | Level 2 | B1 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | B1
738507 | 1E06 | Level 1 | B1 | L41B | 3 | <not associated> | B1
768080 | 2D04-A | Level 2 | B1 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | B1
739294 | 1D07 | Level 1 | C18 | L41C | 3 | <not associated> | C18
766021 | 2C22 | Level 2 | B1 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | B1
770871 | 2D20 | Level 2 | B1 | L42B | 7 | Linked Revit Model : Clinic_A.rvt | B1
739150 | 1D20 | Level 1 | B1 | L41C | 5 | <not associated> | B1
769117 | 2D06 | Level 2 | B1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | B1
740834 | 1C02 | Level 1 | B1 | N21C1 | 22 | <not associated> | B1
769336 | 2D10 | Level 2 | C1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | C1
770488 | 2D17 | Level 2 | B1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | B1
769730 | 2D16 | Level 2 | B1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | B1
773564 | 2B8 | Level 2 | B1 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | B1
739558 | 1C18 | Level 1 | C18 | L41C | 4 | <not associated> | C18
771541 | 2B16 | Level 2 | B1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | B1
759007 | 2A08 | Level 2 | A3 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | A3
758776 | 2A09 | Level 2 | A3 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | A3
766791 | 2B7 | Level 2 | B1 | L42B | 1 | <not associated> | B1
758716 | 2C02 | Level 2 | A3 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | A3
738703 | 1E14 | Level 1 | B1 | L41B | 5 | <not associated> | B1
738838 | 1D25 | Level 1 | B1B | L41B | 5 | <not associated> | B1B
739420 | 1D16 | Level 1 | B1B | L41C | 5 | <not associated> | B1B
739805 | 1A16 | Level 1 | A2B | N21C1 | 24 | <not associated> | A2B
758524 | 2C04 | Level 2 | A3 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | A3
740264 | 1E24 | Level 1 | B1 | L41B | 7 | <not associated> | B1
759301 | 2A07 | Level 2 | A3 | L42C | 8 | Linked Revit Model : Clinic_A.rvt | A3
740944 | 1E23 | Level 1 | B1 | L41B | 6 | <not associated> | B1
761900 | 2A14 | Level 2 | B1 | L42C | 7 | Linked Revit Model : Clinic_A.rvt | B1
740292 | 1E24 | Level 1 | B1 | L41B | 7 | <not associated> | B1
740874 | 1D38 | Level 1 | C18 | L41B | 4 | <not associated> | C18
740252 | 1E24 | Level 1 | B1 | L41B | 7 | <not associated> | B1
768139 | 2D04-A | Level 2 | B1 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | B1
738523 | 1E06 | Level 1 | B1 | L41B | 3 | <not associated> | B1
738531 | 1E06 | Level 1 | B1B | L41B | 3 | <not associated> | B1B
766443 | 2B3 | Level 2 | B1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | B1
760806 | 2A13 | Level 2 | B1 | L42C | 7 | Linked Revit Model : Clinic_A.rvt | B1
744063 | 1C17 | Level 1 | B1 | L41C | 4 | <not associated> | B1
770319 | 2D15 | Level 2 | B1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | B1
758959 | 2A08 | Level 2 | A3 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | A3
740052 | 1A07 | Level 1 | B1 | L41C | 1 | <not associated> | B1
739428 | 1D16 | Level 1 | B1 | L41C | 5 | <not associated> | B1
760938 | 2A12 | Level 2 | A2 | L42C | 7 | Linked Revit Model : Clinic_A.rvt | A2
740882 | 1E01 | Level 1 | B1 | L41B | 3 | <not associated> | B1
772499 | 2B25 | Level 2 | B1 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | B1
763665 | 2C08 | Level 2 | B1B | L42C | 2 | Linked Revit Model : Clinic_A.rvt | B1B
770782 | 2D20 | Level 2 | B1B | L42B | 7 | Linked Revit Model : Clinic_A.rvt | B1B
739831 | 1A16 | Level 1 | A2 | N21C1 | 24 | <not associated> | A2
773147 | 2B14 | Level 2 | B1 | L42B | 3 | <not associated> | B1
770733 | 2D20 | Level 2 | B1 | L42B | 7 | Linked Revit Model : Clinic_A.rvt | B1
762164 | 2A14 | Level 2 | B1 | L42C | 7 | Linked Revit Model : Clinic_A.rvt | B1
766933 | 2B9 | Level 2 | B1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | B1
739332 | 1D11 | Level 1 | C18 | L41C | 3 | <not associated> | C18
766651 | 2B4 | Level 2 | C1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | C1
738675 | 1E33 | Level 1 | B1 | L41B | 3 | <not associated> | B1
740922 | 1E04 | Level 1 | B1 | L41B | 3 | <not associated> | B1
767338 | 2D03 | Level 2 | B1 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | B1
740074 | 1E16 | Level 1 | B1 | L41B | 6 | <not associated> | B1
738399 | 1D38 | Level 1 | C18 | L41B | 4 | <not associated> | C18
759156 | 2A07 | Level 2 | A3 | L42C | 8 | Linked Revit Model : Clinic_A.rvt | A3
768769 | 2D08 | Level 2 | B1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | B1
740966 | 1B17 | Level 1 | B1 | L41B | 1 | <not associated> | B1
761751 | 2A11 | Level 2 | B1B | L42C | 7 | Linked Revit Model : Clinic_A.rvt | B1B
773282 | 2B10 | Level 2 | B1 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | B1
773377 | 2B10 | Level 2 | B1 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | B1
761127 | 2A12 | Level 2 | A2 | L42C | 7 | Linked Revit Model : Clinic_A.rvt | A2
740222 | 1E24 | Level 1 | B1 | L41B | 7 | <not associated> | B1
739841 | 1A14 | Level 1 | A2 | N21C1 | 24 | <not associated> | A2
764374 | 2C17 | Level 2 | D18 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | D18
762334 | 2A14 | Level 2 | B1B | L42C | 7 | Linked Revit Model : Clinic_A.rvt | B1B
764308 | 2C17 | Level 2 | D18 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | D18
763883 | 2C07 | Level 2 | B1 | L42C | 2 | <not associated> | B1
744088 | 1C18 | Level 1 | B1 | L41C | 4 | <not associated> | B1
739861 | 1A15 | Level 1 | B1 | N21C1 | 24 | <not associated> | B1
740814 | 1C10 | Level 1 | B18 | N21C1 | 22 | <not associated> | B18
762088 | 2A14 | Level 2 | B1 | L42C | 7 | Linked Revit Model : Clinic_A.rvt | B1
740044 | 1A07 | Level 1 | B1 | L41C | 1 | <not associated> | B1
740274 | 1E24 | Level 1 | B1 | L41B | 7 | <not associated> | B1
768528 | 2D09 | Level 2 | B1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | B1
761838 | 2A11 | Level 2 | B1 | L42C | 7 | Linked Revit Model : Clinic_A.rvt | B1
772088 | 2B24 | Level 2 | B1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | B1
765853 | 2C03 | Level 2 | C1 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | C1
739647 | 1C14 | Level 1 | B1 | L41C | 4 | <not associated> | B1
765207 | 2C19 | Level 2 | B1 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | B1
773621 | 2B8 | Level 2 | B1 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | B1
763756 | 2C08 | Level 2 | B1 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | B1
763429 | 2C10 | Level 2 | A2 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | A2
768973 | 2D07 | Level 2 | B1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | B1
768866 | 2D07 | Level 2 | B1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | B1
770835 | 2D20 | Level 2 | B1 | L42B | 7 | Linked Revit Model : Clinic_A.rvt | B1
764496 | 2C17 | Level 2 | D18 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | D18
765785 | 2C01 | Level 2 | C1 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | C1
738515 | 1E06 | Level 1 | B1 | L41B | 3 | <not associated> | B1
760014 | 2A04 | Level 2 | B1 | L42C | 6 | Linked Revit Model : Clinic_A.rvt | B1
768435 | 2D09 | Level 2 | B1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | B1
738685 | 1E33 | Level 1 | B1 | L41B | 3 | <not associated> | B1
766086 | 2C22 | Level 2 | B1 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | B1
740062 | 1A16 | Level 1 | A2 | N21C1 | 24 | <not associated> | A2
769515 | 2D11 | Level 2 | B1 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | B1
739566 | 1C18 | Level 1 | C18 | L41C | 4 | <not associated> | C18
740036 | 1A06 | Level 1 | B1 | L41C | 1 | <not associated> | B1
760132 | 2A03 | Level 2 | B1 | L42C | 6 | Linked Revit Model : Clinic_A.rvt | B1
764213 | 2C17 | Level 2 | D18 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | D18
763991 | 2C07 | Level 2 | B1 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | B1
773454 | 2B10 | Level 2 | B1B | L42B | 3 | Linked Revit Model : Clinic_A.rvt | B1B
758896 | 2A08 | Level 2 | A3 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | A3
765913 | 2C03 | Level 2 | C1 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | C1
761042 | 2A12 | Level 2 | A2B | L42C | 7 | Linked Revit Model : Clinic_A.rvt | A2B
740868 | 1D38 | Level 1 | C18 | L41B | 4 | <not associated> | C18
770803 | 2D20 | Level 2 | B1 | L42B | 7 | Linked Revit Model : Clinic_A.rvt | B1
740952 | 1E23 | Level 1 | B1 | L41B | 6 | <not associated> | B1
762237 | 2A14 | Level 2 | B1 | L42C | 7 | <not associated> | B1
765269 | 2C19 | Level 2 | B1 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | B1
764448 | 2C17 | Level 2 | D18 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | D18
740932 | 1E22 | Level 1 | B1 | L41B | 6 | <not associated> | B1
760579 | 2A02 | Level 2 | B1 | L42C | 6 | Linked Revit Model : Clinic_A.rvt | B1
765736 | 2C01 | Level 2 | C1 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | C1
759199 | 2A07 | Level 2 | A3 | L42C | 8 | Linked Revit Model : Clinic_A.rvt | A3
773497 | 2B8 | Level 2 | B1 | L42B | 3 | <not associated> | B1
768213 | 2D04-A | Level 2 | B1 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | B1
765075 | 2C12 | Level 2 | A2 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | A2
765468 | 2C08 | Level 2 | B1 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | B1
764616 | 2C17 | Level 2 | D18 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | D18
740028 | 1A06 | Level 1 | B1 | L41C | 1 | <not associated> | B1
765313 | 2C19 | Level 2 | B1 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | B1
764970 | 2C12 | Level 2 | A2 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | A2
766379 | 2B3 | Level 2 | B1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | B1
765582 | 2C03 | Level 2 | C1 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | C1
766284 | 2B3 | Level 2 | B1 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | B1
760486 | 2A02 | Level 2 | B1 | L42C | 6 | Linked Revit Model : Clinic_A.rvt | B1
765029 | 2C12 | Level 2 | A2 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | A2
760217 | 2A03 | Level 2 | B1 | L42C | 6 | Linked Revit Model : Clinic_A.rvt | B1
765675 | 2C03 | Level 2 | C1 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | C1

# IfcFlowTerminal: 100W - 120V (6)
Type - ElementType: 100W - 120V
PSet_Revit_Electrical - Lighting - Calculate Coefficient of Utilization: no
PSet_Revit_Constraints - Elevation: 2 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - Schedule Level: Level 1; TagNumber: T1; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Electrical - Loads - Panel: L41C
PSet_Revit_Identity Data - Mark: T1
PSet_Revit_Electrical - Circuiting - Electrical Data: 120 V/1-100 VA
PSet_Revit_Type_Electrical - Loads - Apparent Load: 1076.39
PSet_Revit_Type_Electrical - Load Classification: Lighting - Dwelling Unit; Lamp: R-30; Ballast Voltage: 1291.67; Ballast Number of Poles: 1
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; Assembly Code: D5020220; Assembly Description: Lighting - Incandescent; OmniClass Number: 23.80.70.11.11; OmniClass Title: General Luminaries, Non Directional
PSet_Revit_Type_Constraints - Default Elevation: 1.9 m
PSet_Revit_Type_Photometrics - Light Source Definition (family): Point+HemiSpherical; Light Loss Factor: 0; Initial Intensity: 0; Initial Color: 0; Dimming Lamp Color Temperature Shift: 0; Color Filter: 16777215
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Materials and Finishes - Shade Material: Glass - Frosted
PSet_Revit_Type_Dimensions - Radius: 0.2 m; Light Source Symbol Size: 0.05 m
Name (M_Sconce Light - Sphere:100W - 120V:100W - 120V:...) | In | Host | Circuit Number
752725 | 1AC1 | Grid : D.9 | 7
753021 | 1AC1 | Linked Revit Model : Clinic_A.rvt | 7
752761 | 1AC1 | Grid : D.9 | 7
927616 | 1DC1 | Grid : D.9 | 8
927617 | 1DC1 | Linked Revit Model : Clinic_A.rvt | 8
753296 | 1AC1 | Linked Revit Model : Clinic_A.rvt | 7

# IfcFlowTerminal: 1200mm - 120V (32)
Type - ElementType: 1200mm - 120V
PSet_Revit_Electrical - Circuiting - Electrical Data: 120 V/1-64 VA
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Electrical - Lighting - Calculate Coefficient of Utilization: no
PSet_Revit_Type_Photometrics - Light Source Definition (family): Point+HemiSpherical; Light Loss Factor: 0; Initial Intensity: 0; Initial Color: 0; Dimming Lamp Color Temperature Shift: 0; Color Filter: 16777215
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Materials and Finishes - Light Casing Material: Metal - Paint Finish - Ivory, Glossy; Diffuser Material: Glass - White, High Luminance; Ceiling Mount Material: Metal - Paint Finish - Ivory, Glossy
PSet_Revit_Type_Constraints - Default Elevation: 1.2 m
PSet_Revit_Type_Dimensions - Light Source Symbol Size: 0.05 m; Light Casing Length: 1.2 m; Drop From Ceiling: 0.6 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; Assembly Code: D5020210; Assembly Description: Lighting - Fluorescent; OmniClass Number: 23.80.70.11.11; OmniClass Title: General Luminaries, Non Directional
PSet_Revit_Type_Electrical - Load Classification: Lighting - Dwelling Unit; Lamp: T-12; Ballast Voltage: 1291.67; Ballast Number of Poles: 1
PSet_Revit_Type_Electrical - Loads - Apparent Load: 688.89
Name (M_Pendant Light - Linear - 2 Lamp:1200mm - 120V:1200mm - 120V:...) | In | Mark = TagNumber | Panel | Circuit Number | Host | Elevation (m) | Schedule Level
745294 | 1B16 | Q1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
750622 | 1B21 | Q4 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
750727 | 1B23 | Q4 | L41B | 8 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
745370 | 1B12 | R1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
825760 | 1C03 | Q4 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
745835 | 1E20 | Q4B | L41B | 6 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
745874 | 1E21 | Q4 | L41B | 6 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
745356 | 1B14 | R1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
745555 | 1B07 | R1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
750581 | 1B21 | Q4B | L41B | 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
826740 | 1A11 | Q1 | N21C1 | 24 | <not associated> | 2.8 | Level 1
750780 | 1B23 | Q4B | L41B | 8 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
744273 | 1C13 | Q4 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
746053 | 1E19 | Q4B | L41B | 6 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
827331 | 1E17 | Q4 | L41B | 6 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
745477 | 1B09 | R1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
776471 | 2B13 | Q4B | L42B | 3 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 2
744933 | 1E15 | Q4 | L41B | 5 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
745992 | 1E19 | Q4 | L41B | 6 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
826248 | 1E02 | Q4 | L41B | 3 | <not associated> | 2.8 | Level 1
776596 | 2B12 | Q4B | L42B | 3 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 2
850985 | 2B20 | Q1 | L42B | 1 | <not associated> | 2.8 | Level 2
744180 | 1C13 | Q4 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
826374 | 1E03 | Q4 | L41B | 3 | <not associated> | 2.8 | Level 1
745757 | 1E20 | Q4 | L41B | 6 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
825912 | 1D17 | Q1 | L41C | 5 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
744703 | 1E15 | Q4 | L41B | 5 | <not associated> | 2.8 | Level 1
776509 | 2B13 | Q4 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 2
744837 | 1E15 | Q4B | L41B | 5 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
776627 | 2B12 | Q4 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 2
744869 | 1E15 | Q4 | L41B | 5 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 1
776789 | 2BS2 | E1 | L42B | 4 | Linked Revit Model : Clinic_A.rvt | 2.68 | Level 2

# IfcFlowTerminal: 1200mm - 120V_ 1m Drop (31)
Type - ElementType: 1200mm - 120V_ 1m Drop
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Electrical - Lighting - Calculate Coefficient of Utilization: no
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Electrical - Circuiting - Electrical Data: 120 V/1-64 VA
PSet_Revit_Type_Photometrics - Light Source Definition (family): Point+HemiSpherical; Light Loss Factor: 0; Initial Intensity: 0; Initial Color: 0; Dimming Lamp Color Temperature Shift: 0; Color Filter: 16777215
PSet_Revit_Type_Materials and Finishes - Light Casing Material: Metal - Paint Finish - Ivory, Glossy; Diffuser Material: Glass - White, High Luminance; Ceiling Mount Material: Metal - Paint Finish - Ivory, Glossy
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; Assembly Code: D5020210; Assembly Description: Lighting - Fluorescent; OmniClass Number: 23.80.70.11.11; OmniClass Title: General Luminaries, Non Directional
PSet_Revit_Type_Electrical - Loads - Apparent Load: 688.89
PSet_Revit_Type_Constraints - Default Elevation: 1.2 m
PSet_Revit_Type_Electrical - Load Classification: Lighting - Dwelling Unit; Lamp: T-12; Ballast Voltage: 1291.67; Ballast Number of Poles: 1
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Dimensions - Light Source Symbol Size: 0.05 m; Light Casing Length: 1.2 m; Drop From Ceiling: 2 m
Name (M_Pendant Light - Linear - 2 Lamp:1200mm - 120V_ 1m Drop:1200mm - 120V_ 1m Drop:...) | In | Panel | Circuit Number | Schedule Level | TagNumber = Mark | Host | Elevation (m)
745139 | 1ES2 | L41B | 2 | Level 1 | E1 | Linked Revit Model : Clinic_S.rvt | 4.468
775091 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68
775261 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68
774911 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68
775523 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68
774387 | 2D05 | L42C | 9 | Level 2 | Q4B | Linked Revit Model : Clinic_S.rvt | 4.68
783301 | 2C18 | L42C | 1 | Level 2 | Q4B | Linked Revit Model : Clinic_S.rvt | 4.6735
775226 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68
775170 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68
774993 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68
774744 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68
775447 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68
774861 | 2D05 | L42C | 9 | Level 2 | Q4B | Linked Revit Model : Clinic_S.rvt | 4.68
843057 | 2B2 | L42B | 1 | Level 2 | Q1 | <not associated> | 4.68
775907 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68
774451 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68
774298 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.6735
774680 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68
776018 | 2D05 | L42C | 9 | Level 2 | Q4B | Linked Revit Model : Clinic_S.rvt | 4.68
849854 | 2C05 | L42C | 2 | Level 2 | Q1 | Linked Revit Model : Clinic_S.rvt | 4.68
783310 | 2C18 | L42C | 1 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.6735
775330 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68
783328 | 2C15 | L42C | 1 | Level 2 | Q4B | Linked Revit Model : Clinic_S.rvt | 4.6735
774522 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68
774621 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68
775855 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68
774134 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68
775688 | 2D05 | L42C | 9 | Level 2 | Q4B | Linked Revit Model : Clinic_S.rvt | 4.68
783320 | 2C15 | L42C | 1 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.6735
775734 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68
775602 | 2D05 | L42C | 9 | Level 2 | Q4 | Linked Revit Model : Clinic_S.rvt | 4.68

# IfcFlowTerminal: 15 mm Pendent (418)
Type - ElementType: 15 mm Pendent
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Fire Protection - Pressure Drop: 14721.8; Flow: 0.0706293
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection
PSet_Revit_Graphics - Symbol: M_Sprinkler - Symbol - Pendent : Sprinkler - Symbol - Pendent
PSet_Revit_Constraints - Offset: 0 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Dimensions - Escutcheon Diameter: 0.0492126; Nominal Diameter: 0.0492126; Nominal Radius: 0.0246063; Escutcheon Radius: 0.0246063; Protrusion: 0.173885; Overall Length: 0.19685; Escutcheon Thickness: 0.00984252; CEL: 0.0229659
PSet_Revit_Type_Fire Protection - Temperature Rating: 330.15; Response: 0; Pressure Class: 0; Orifice Size: 0.0426509; Orifice: 0; K-Factor: 81; Coverage: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.65.70.17.11.24; OmniClass Title: Fire Fighting Sprinkler Heads
PSet_Revit_Type_Constraints - Default Elevation: 2.4 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Sprinkler - Pendent - Hosted:15 mm Pendent:15 mm Pendent:...) | In | Schedule Level | Host | Elevation (m) | Mark
1028252 | 1DC3 | Level 1 | <not associated> | 2.8 | 212
1051384 | E1 | Level 2 | <not associated> | 2.8 | 456
1003564 | 1E18 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 6
1003161 | 1E20 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 2
1028156 | 1DC3 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 211
1036092 | 2C07 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 260
1003261 | 1E17 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 3
1028387 | 1DC3 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 214
1003890 | 1E16 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 12
1028335 | 1DC3 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 213
1038271 | 2CC4 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 296
1003667 | 1E30 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 8
1024507 | 1E07 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 199
1036531 | 2CC1 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 267
1011758 | 1C04 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 93
1003614 | 1E16 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 7
1003471 | 1E21 | Level 1 | <not associated> | 2.8 | 5
1004575 | 1E24 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 17
1004021 | 1EC1 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 13
1024720 | 1E06 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 200
1004245 | 1E24 | Level 1 | <not associated> | 2.8 | 14
1033598 | 2AC3 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 233
1012033 | 1C19 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 100
1017740 | 1A15 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 140
1024450 | 1E08 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 198
1016168 | 1DC2 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 127
1015009 | 1BC4 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 116
1035913 | 2C03 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 258
1017993 | 1A13 | Level 1 | <not associated> | 2.8 | 142
1036689 | 2CC1 | Level 2 | <not associated> | 2.8 | 269
1010771 | 1C01 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 81
1015390 | 1E03 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 119
1017195 | 1D02 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 136
1015308 | 1D38 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 117
1015356 | 1D36 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 118
1009055 | 1D19 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 61
1048500 | 2D05 | Level 2 | <not associated> | 2.8 | 431
1033384 | 2CC2 | Level 2 | <not associated> | 2.8 | 231
1004659 | 1E28 | Level 1 | <not associated> | 2.8 | 18
1003076 | 1E16 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 1
1039344 | 2C17 | Level 2 | <not associated> | 2.8 | 307
1003430 | 1E22 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 4
1038247 | 2CC4 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 295
1014911 | 1D40 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 115
1016388 | 1C13 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 128
1024310 | 1B21 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 196
1004720 | 1E27 | Level 1 | <not associated> | 2.8 | 19
1036025 | 2C22 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 259
1017255 | 1D04 | Level 1 | <not associated> | 2.8 | 137
1014756 | 1D35 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 112
1048726 | 2D06 | Level 2 | <not associated> | 2.8 | 455
1011643 | 1CC1 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 91
1014407 | 1DC7 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 109
1005153 | 1E26 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 21
1048716 | 2D05 | Level 2 | <not associated> | 2.8 | 454
1021178 | 1B03 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 167
1016120 | 1D08 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 126
1035653 | 2AC1 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 255
1046350 | 2BC6 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 410
1033464 | 2AC3 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 232
1022630 | 1B04 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 179
1037559 | 2DC2 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 284
1020986 | 1B13 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 164
1045670 | 2DC1 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 403
1023393 | 1BC4 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 185
1006982 | 1D24 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 44
1018057 | 1AC4 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 143
1035534 | 2C23 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 253
1048436 | 2D05 | Level 2 | <not associated> | 2.8 | 426
1035822 | 2C23 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 257
1011886 | 1CC3 | Level 1 | <not associated> | 2.8 | 95
1038529 | 2C14 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 298
1048596 | 2D05 | Level 2 | <not associated> | 2.8 | 441
1024036 | 1BC2 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 195
1036152 | 2C07 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 262
1014299 | 1DC6 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 108
1036208 | 2C08 | Level 2 | <not associated> | 2.8 | 263
1014838 | 1DC7 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 114
1045467 | 2BC1 | Level 2 | <not associated> | 2.8 | 399
1005401 | 1E10 | Level 1 | <not associated> | 2.8 | 25
1024401 | 1E24 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 197
1003807 | 1E19 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 11
1038072 | 2CC3 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 293
1004465 | 1E24 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 16
1026359 | 1A06 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 210
1045770 | 2DC1 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 404
1015471 | 1BC4 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 121
1008691 | 1DC1 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | 58
1038139 | 2CC3 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 294
1021365 | 1BC1 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 169
1048522 | 2D05 | Level 2 | <not associated> | 2.8 | 433
1033744 | 2AC3 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 235
1021423 | 1B02 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 170
1015417 | 1E05 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 120
1009858 | 1D17 | Level 1 | <not associated> | 2.8 | 68
1031822 | 2A09 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 220
1008761 | 1DC1 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | 59
1012223 | 1C09 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 105
1036872 | 2DC2 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 271
1045412 | 2B12 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 398
1005477 | 1EC3 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 26
1046136 | 2D02 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 408
1046383 | 2B11 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 411
1012089 | 1C14 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 102
1038911 | 2C17 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 303
1012061 | 1C16 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 101
1008601 | 1DC1 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | 57
1036327 | 2C07 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 264
1031988 | 2C02 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 221
1009470 | 1D14 | Level 1 | <not associated> | 2.8 | 65
1031677 | 2A08 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 219
1008408 | 1DC1 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 54
1006493 | 1D30 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 39
1016706 | 1CC1 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 131
1012332 | 1C05 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 107
1010955 | 1CC1 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 82
1011575 | 1CC1 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 90
1005530 | 1E12 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 27
1039539 | 2C19 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 309
1047267 | 2D03 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 423
1006163 | 1D26 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 36
1006896 | 1D27 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 43
1011929 | 1C18 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 96
1017874 | 1A14 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 141
1046683 | 2B7 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 417
1007292 | 1DC1 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | 47
1048578 | 2D05 | Level 2 | <not associated> | 2.8 | 439
1048588 | 2D05 | Level 2 | <not associated> | 2.8 | 440
1044482 | 2BC2 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 376
1025973 | 1E01 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 206
1005676 | 1E14 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 30
1007652 | 1DC1 |  | Linked Revit Model : Clinic_A.rvt | 0 | 51
1019311 | 1A02 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 152
1047378 | 2BC1 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 424
1026135 | 1B23 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 208
1039459 | 2C18 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 308
1007651 | 1DC1 |  | <not associated> | 0 | 50
1039203 | 2C10 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 306
1009674 | 1DC4 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 67
1032636 | 2C03 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 226
1036125 | 2C08 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 261
1035789 | 2AC1 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 256
1015633 | 1E06 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 122
1011952 | 1C18 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 97
1048512 | 2D05 | Level 2 | <not associated> | 2.8 | 432
1022292 | 1B19 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 177
1048672 | 2D05 | Level 2 | <not associated> | 2.8 | 449
1010043 | 1D16 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 72
1017400 | 1AC2 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 139
1010476 | 1D07 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 78
1010115 | 1D16 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 73
1003724 | 1EC4 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 9
1008448 | 1DC1 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 55
1006021 | 1D25 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 35
1046654 | 2BC5 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 416
1045276 | 2B10 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 395
1014519 | 1D34 | Level 1 | <not associated> | 2.8 | 110
1031620 | 2A07 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 218
1035579 | 2C03 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 254
1005229 | 1E25 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 23
1040433 | 2A14 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 323
1015754 | 1DC6 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 123
1046053 | 2D04 | Level 2 | <not associated> | 2.8 | 407
1036756 | 2DC2 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 270
1033660 | 2AC3 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 234
1008942 | 1DC1 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 60
1047021 | 2D04-A | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 421
1026311 | 1A07 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 209
1019482 | 1A04 | Level 1 | <not associated> | 2.8 | 154
1019631 | 1AC5 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 155
1023555 | 1BC3 | Level 1 | <not associated> | 2.8 | 188
1031373 | 2A04 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 215
1010655 | 1D05 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 80
1011685 | 1CC1 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 92
1010178 | 1DC4 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 74
1005566 | 1E11 | Level 1 | <not associated> | 2.8 | 28
1005195 | 1E29 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 22
1023650 | 1B16 | Level 1 | <not associated> | 2.8 | 189
1009119 | 1D20 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 62
1044568 | 2BC2 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 377
1007654 | 1D22 |  | Linked Revit Model : Clinic_A.rvt | 0 | 53
1033895 | 2A03 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 238
1006658 | 1D33 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 41
1016463 | 1C15 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 129
1045585 | 2D01 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 402
1035259 | 2A11 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 250
1019924 | 1A08 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 158
1048486 | 2CC1 | Level 2 | <not associated> | 2.8 | 430
1007344 | 1DC1 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.8 | 48
1038495 | 2C13 | Level 2 | Linked Revit Model : Clinic_A.rvt | 2.68 | 297
1011314 | 1AC3 | Level 1 | <not associated> | 2.8 | 88
1020083 | 1A12 | Level 1 | Linked Revit Model : Clinic_A.rvt | 2.68 | 160
