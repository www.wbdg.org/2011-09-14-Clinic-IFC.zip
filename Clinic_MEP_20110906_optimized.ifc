Properties of the parts of a building model (IFC2X3), part 9 of 295

# IfcFlowFitting: 1 D (113)
Name (M_Round Elbow:1 D:1 D:...) | In | Mark | Radius = Lining Radius = Insulation Radius | Length1 | Center Radius | Angle (deg) | Size | System Name | Level | Host | Offset (m) | ASHRAE Table
569662 | 2B14 | 7542 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33 | CD3-17
568390 | 1E06 | 5141 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Mechanical Supply Air 1 | Level 1 | Level : Level 1 | 3.3 | CD3-11
569596 | 2D18 | 7395 | 0.410105 | 0.82021 | 0.82021 | 90 | 250ø-250ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.28 | CD3-11
569706 | 2D04-A | 7686 | 0.492126 | 0.984252 | 0.984252 | 90 | 300ø-300ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-11
569267 | 2C10 | 6412 | 0.410105 | 0.82021 | 0.82021 | 90 | 250ø-250ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08 | CD3-11
567921 | 1AC5 | 3579 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 1 | Level 2 | Level : Level 2 | -0.87 | CD3-11
570785 | 2D05 | 700 | 1.23031 | 0.682393 | 2.46063 | 31 | 750ø-750ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08
569080 | 2AC4 | 5921 | 0.574147 | 1.14829 | 1.14829 | 90 | 350ø-350ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08 | CD3-11
569376 | 2C19 | 6760 | 0.328084 | 0.271794 | 0.656168 | 45 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.43952 | CD3-17
567575 | 1BC1 | 2429 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Mechanical Supply Air 1 | Level 1 | Level : Level 1 | 3.79952 | CD3-11
1120262 | 1D32 | 1081 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 1 | Level 1 | Level : Level 1 | 3.2905 | CD3-11
569753 | 2D18 | 7810 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33 | CD3-17
568385 | 1EC1 | 5133 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 1 | Level 1 | Level : Level 1 | 3.3 | CD3-11
568416 | 1B15 | 5189 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Mechanical Supply Air 1 | Level 2 | Level : Level 2 | -0.770484 | CD3-11
570715 | 1D36 | 568 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 1 | Level 2 | Level : Level 2 | -0.78 | CD3-11
569723 | 2DC2 | 7736 | 0.328084 | 0.271794 | 0.656168 | 45 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-17
569720 | 2DC2 | 7720 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-11
569754 | 2D18 | 7812 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33 | CD3-11
569752 | 2D18 | 7807 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 2 | Level 2 | Level : Level 2 | 3.35 | CD3-11
569266 | 2CC1 | 6407 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08 | CD3-11
568148 | 1CC1 | 4336 | 0.410105 | 0.82021 | 0.82021 | 90 | 250ø-250ø | Mechanical Supply Air 1 | Level 2 | Level : Level 2 | -1.27 | CD3-11
569724 | 2DC2 | 7738 | 0.328084 | 0.271794 | 0.656168 | 45 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.48 | CD3-17
569800 | 2D18 | 7920 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.27052 | CD3-11
1120673 | 1BC2 | 1125 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 1 | Level 1 | Level : Level 1 | 3.37 | CD3-11
570664 | 1A16 | 414 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 1 | Level 1 | Level : Level 1 | 3.7095 | CD3-11
568151 | 1DC4 | 4342 | 0.410105 | 0.82021 | 0.82021 | 90 | 250ø-250ø | Mechanical Supply Air 1 | Level 2 | Level : Level 2 | -1.27 | CD3-11
1120645 | 1B07 | 1123 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 1 | Level 1 | Level : Level 1 | 3.4 | CD3-11
570580 | 1A08 | 122 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Mechanical Supply Air 1 | Level 1 | Level : Level 1 | 3.3 | CD3-11
1137353 | 1E16 | 1314 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 1 | Level 1 | Level : Level 1 | 3.4146 | CD3-11
1120512 | 1DC7 | 1119 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 1 | Level 1 | Level : Level 1 | 3.2905 | CD3-11
1137315 | 2BC6 | 1313 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 2 | Level 2 | Level : Level 2 | 3.35 | CD3-11
1101493 | 1B17 | 418 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Mechanical Supply Air 1 | Level 1 | Level : Level 1 | 3.5 | CD3-11

# IfcFlowFitting: 1.5 D (6)
Type - ElementType: 1.5 D
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Mechanical - Lining Thickness: 0; Insulation Thickness: 0; System Type: Supply Air; System Name: Mechanical Supply Air 1; Loss Method: 1
PSet_Revit_Constraints - Level: Level 1; Host: Level : Level 1
PSet_Revit_Type_Dimensions - Radius Multiplier: 1.5
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Round Elbow:1.5 D:1.5 D:...) | In | Radius = Lining Radius = Insulation Radius | Length1 | Center Radius | Angle (deg) | Size | ASHRAE Table | Mark | Offset (m)
567305 | 1E07 | 0.328084 | 0.407691 | 0.984252 | 45 | 200ø-200ø | CD3-17 | 1595 | 3.5
567313 | 1E07 | 0.328084 | 0.984252 | 0.984252 | 90 | 200ø-200ø | CD3-1 | 1612 | 3.5
567302 | 1E06 | 0.328084 | 0.984252 | 0.984252 | 90 | 200ø-200ø | CD3-1 | 1590 | 3.79
567303 | 1E07 | 0.328084 | 0.407691 | 0.984252 | 45 | 200ø-200ø | CD3-17 | 1591 | 3.79
567314 | 1E07 | 0.328084 | 0.984252 | 0.984252 | 90 | 200ø-200ø | CD3-1 | 1614 | 3.5
567336 | 1EC1 | 0.656168 | 1.9685 | 1.9685 | 90 | 400ø-400ø | CD3-11 | 1709 | 3.79

# IfcFlowFitting: 1.5 W (7)
Type - ElementType: 1.5 W
PSet_Revit_Mechanical - Lining Thickness: 0; Insulation Thickness: 0; Loss Method: 1
PSet_Revit_Constraints - Level: Level 1; Host: Level : Level 1
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Dimensions - Radius Multiplier: 1.5
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Rectangular Elbow - Radius:1.5 W:1.5 W:...) | In | Width = Lining Width = Insulation Width | Lining Height = Insulation Height = Height | Length1 | Center Radius | Angle (deg) | Size | System Type | System Name | Offset (m) | Mark
567370 | 1BC4 | 0.492126 | 0.984252 | 0.305768 | 0.738189 | 45 | 150x300-150x300 | Supply Air | Mechanical Supply Air 1 | 3.3 | 1788 | PSet_Revit_Mechanical - ASHRAE Table: CR3-1
567283 | Level 1 | 0.984252 | 2.46063 | 0.611536 | 1.47638 | 45 | 300x750-300x750 | Return Air | Mechanical Return Air 1 | 3.25 | 1521
567372 | 1BC4 | 0.492126 | 0.984252 | 0.305768 | 0.738189 | 45 | 150x300-150x300 | Supply Air | Mechanical Supply Air 1 | 3.78998 | 1795 | PSet_Revit_Mechanical - ASHRAE Table: CR3-1
567064 | 1D36 | 0.984252 | 3.60892 | 0.611536 | 1.47638 | 45 | 300x1100-300x1100 | Return Air | Mechanical Return Air 1 | 3.25 | 1109
567068 | 1D36 | 3.60892 | 0.984252 | 0.52125 | 5.41339 | 11 | 1100x300-1100x300 | Return Air | Mechanical Return Air 1 | 3.25 | 1122
567066 | 1D36 | 3.60892 | 0.984252 | 0.52125 | 5.41339 | 11 | 1100x300-1100x300 | Return Air | Mechanical Return Air 1 | 3.25 | 1121
567762 | 1D40 | 0.492126 | 0.82021 | 0.738189 | 0.738189 | 90 | 150x250-150x250 | Supply Air | Mechanical Supply Air 1 | 3.30951 | 3090 | PSet_Revit_Mechanical - ASHRAE Table: SR3-1

# IfcFlowFitting: 125 mm Strainer - 100 mm Drain (5)
Type - ElementType: 125 mm Strainer - 100 mm Drain; PredefinedType: ENTRY
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: FD; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Host: Pipe Types : Waste
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1
PSet_Revit_Type_Other - Radius 6: 0.015625 m; Radius 5: 0.03125 m; Radius 4: 0.046875 m; Radius 2: 0.0853333 m; Radius 1: 0.0676667 m; Radius 3: 0.0515 m; Height 2: 0.0184 m; Height 1: 0.046 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; Type Mark: FD; OmniClass Number: 23.45.55.21; OmniClass Title: Drains (Wastes)
PSet_Revit_Type_Mechanical - WFU: 4; HWFU: 0; CWFU: 0
PSet_Revit_Type_Dimensions - Strainer Height: 0.083 m; Strainer Radius: 0.0625 m; Strainer Diameter: 0.125 m; Pipe Radius: 0.164042; Pipe Diameter: 0.328084; Body Radius: 0.103 m; Body Height: 0.092 m; Body Diameter: 0.206 m
PSet_Revit_Type_Constraints - Default Elevation: 0 m
Name (M_Floor Drain - Round:125 mm Strainer - 100 mm Drain:125 mm Strainer - 100 mm Drain:...) | In | Schedule Level | Mark | Elevation (m)
669691 | 2D05 | Level 2 | 116 | -0.0587375
669363 | 2D05 | Level 1 | 115 | 4.51126
669201 | 2D05 | Level 1 | 113 | 4.51126
669280 | 2D05 | Level 1 | 114 | 4.51126
1083711 | 2A13 | Level 1 | 157 | 4.57

# IfcFlowFitting: 2 D (83)
Type - ElementType: 2 D
PSet_Revit_Mechanical - Lining Thickness: 0; Insulation Thickness: 0; System Type: Supply Air; System Name: Mechanical Supply Air 1; Loss Method: 1
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Dimensions - Radius Multiplier: 2
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
Name (M_Round Elbow:2 D:2 D:...) | In | Radius = Lining Radius = Insulation Radius | Length1 | Center Radius | Angle (deg) | Size | ASHRAE Table | Mark | Level | Host | Offset (m)
567377 | 1EC1 | 0.328084 | 0.543587 | 1.31234 | 45 | 200ø-200ø | CD3-17 | 1813 | Level 1 | Level : Level 1 | 3.79
568285 | 1D12 | 0.328084 | 1.31234 | 1.31234 | 90 | 200ø-200ø | CD3-11 | 4824 | Level 2 | Level : Level 2 | -0.86052
568227 | 1D16 | 0.328084 | 1.31309 | 1.31234 | 90.0329 | 200ø-200ø |  | 4596 | Level 2 | Level : Level 2 | -1.37
568244 | 1DC4 | 0.328084 | 1.3119 | 1.31234 | 89.981 | 200ø-200ø |  | 4655 | Level 2 | Level : Level 2 | -1.07
567520 | 1BC2 | 0.246063 | 0.52874 | 0.984252 | 56.4894 | 150ø-150ø |  | 2312 | Level 1 | Level : Level 1 | 3.37
567479 | 1B19 | 0.492126 | 1.9685 | 1.9685 | 90 | 300ø-300ø | CD3-11 | 2223 | Level 1 | Level : Level 1 | 3.6996
567926 | 1A07 | 0.328084 | 0.774223 | 1.31234 | 61.0777 | 200ø-200ø |  | 3594 | Level 2 | Level : Level 2 | -0.860493
567515 | 1BC2 | 0.246063 | 0.984252 | 0.984252 | 90 | 150ø-150ø | CD3-11 | 2306 | Level 1 | Level : Level 1 | 3.37
567550 | 1B13 | 0.328084 | 1.31234 | 1.31234 | 90 | 200ø-200ø | CD3-11 | 2368 | Level 1 | Level : Level 1 | 3.79951
567698 | 1D36 | 0.82021 | 1.30917 | 3.28084 | 43.5074 | 500ø-500ø |  | 2871 | Level 1 | Level : Level 1 | 3.69
568340 | 1D05 | 0.410105 | 0.580903 | 1.64042 | 39 | 250ø-250ø |  | 4992 | Level 2 | Level : Level 2 | -0.860482
567398 | 1E29 | 0.246063 | 0.984252 | 0.984252 | 90 | 150ø-150ø | CD3-11 | 1931 | Level 1 | Level : Level 1 | 3.5
568349 | 1D04 | 0.492126 | 0.0431668 | 1.9685 | 2.51245 | 300ø-300ø |  | 5004 | Level 2 | Level : Level 2 | -0.850424
568228 | 1D16 | 0.328084 | 1.31309 | 1.31234 | 90.033 | 200ø-200ø |  | 4597 | Level 2 | Level : Level 2 | -1.27
568182 | 1DC3 | 0.82021 | 0.879098 | 3.28084 | 30 | 500ø-500ø |  | 4420 | Level 2 | Level : Level 2 | -1.07
567489 | 1BC2 | 0.328084 | 0.543587 | 1.31234 | 45 | 200ø-200ø | CD3-17 | 2240 | Level 1 | Level : Level 1 | 3.69
567975 | 1A02 | 0.328084 | 1.31234 | 1.31234 | 90 | 200ø-200ø | CD3-11 | 3768 | Level 2 | Level : Level 2 | -0.860494
567690 | 1E11 | 0.328084 | 1.31234 | 1.31234 | 90 | 200ø-200ø | CD3-11 | 2842 | Level 1 | Level : Level 1 | 3.7995
567406 | 1E24 | 0.328084 | 0.543587 | 1.31234 | 45 | 200ø-200ø | CD3-17 | 2023 | Level 1 | Level : Level 1 | 3.5
567559 | 1B04 | 0.410105 | 1.64204 | 1.64042 | 90.0564 | 250ø-250ø |  | 2377 | Level 1 | Level : Level 1 | 3.79
567539 | 1B17 | 0.328084 | 1.31234 | 1.31234 | 90 | 200ø-200ø | CD3-11 | 2340 | Level 1 | Level : Level 1 | 3.5
567494 | 1B17 | 0.410105 | 1.64042 | 1.64042 | 90 | 250ø-250ø | CD3-11 | 2248 | Level 1 | Level : Level 1 | 3.79
568342 | 1D05 | 0.410105 | 0.580903 | 1.64042 | 39 | 250ø-250ø |  | 4997 | Level 2 | Level : Level 2 | -0.860482
567983 | 1A16 | 0.410105 | 1.64042 | 1.64042 | 90 | 250ø-250ø | CD3-11 | 3801 | Level 2 | Level : Level 2 | -0.87
1120146 | 1BC4 | 0.410105 | 1.64042 | 1.64042 | 90 | 250ø-250ø | CD3-11 | 1053 | Level 1 | Level : Level 1 | 3.41042
567409 | 1E24 | 0.328084 | 1.31285 | 1.31234 | 90.0224 | 200ø-200ø |  | 2038 | Level 1 | Level : Level 1 | 3.5
568181 | 1DC3 | 0.82021 | 0.879098 | 3.28084 | 30 | 500ø-500ø |  | 4418 | Level 2 | Level : Level 2 | -0.87
567467 | 1B04 | 0.574147 | 2.29659 | 2.29659 | 90 | 350ø-350ø | CD3-11 | 2193 | Level 1 | Level : Level 1 | 3.69
567535 | 1B17 | 0.328084 | 0.543587 | 1.31234 | 45 | 200ø-200ø | CD3-17 | 2337 | Level 1 | Level : Level 1 | 3.79
567685 | 1DC6 | 0.246063 | 0.984252 | 0.984252 | 90 | 150ø-150ø | CD3-11 | 2831 | Level 1 | Level : Level 1 | 3.79
567949 | 1AC5 | 0.574147 | 1.27302 | 2.29659 | 58 | 350ø-350ø |  | 3692 | Level 2 | Level : Level 2 | -0.87
567428 | 1B19 | 0.410105 | 1.64042 | 1.64042 | 90 | 250ø-250ø | CD3-11 | 2081 | Level 1 | Level : Level 1 | 3.78048
567669 | 1E14 | 0.328084 | 1.31234 | 1.31234 | 90 | 200ø-200ø | CD3-11 | 2751 | Level 1 | Level : Level 1 | 3.29048
567960 | 1A01 | 0.246063 | 0.984252 | 0.984252 | 90 | 150ø-150ø | CD3-11 | 3739 | Level 2 | Level : Level 2 | -0.860493
568098 | 1C18 | 0.246063 | 0.984252 | 0.984252 | 90 | 150ø-150ø | CD3-11 | 4169 | Level 2 | Level : Level 2 | -1.32
567405 | 1E24 | 0.328084 | 0.543587 | 1.31234 | 45 | 200ø-200ø | CD3-17 | 2021 | Level 1 | Level : Level 1 | 3.79
568347 | 1D04 | 0.492126 | 0.0431668 | 1.9685 | 2.51245 | 300ø-300ø |  | 5000 | Level 2 | Level : Level 2 | -0.87
568296 | 1D11 | 0.328084 | 0.347799 | 1.31234 | 29.6869 | 200ø-200ø |  | 4848 | Level 2 | Level : Level 2 | -1.2605
567700 | 1D38 | 0.574147 | 0.0299156 | 2.29659 | 1.4926 | 350ø-350ø |  | 2901 | Level 1 | Level : Level 1 | 3.69
568321 | 1D04 | 0.328084 | 1.3125 | 1.31234 | 90.0072 | 200ø-200ø |  | 4952 | Level 2 | Level : Level 2 | -0.87
568073 | 1CC2 | 0.328084 | 1.31316 | 1.31234 | 90.0358 | 200ø-200ø |  | 4096 | Level 2 | Level : Level 2 | -1.27
567914 | 1AC5 | 0.492126 | 1.9685 | 1.9685 | 90 | 300ø-300ø | CD3-11 | 3542 | Level 2 | Level : Level 2 | -0.87
567715 | 1D38 | 0.410105 | 1.64042 | 1.64042 | 90 | 250ø-250ø | CD3-11 | 2943 | Level 1 | Level : Level 1 | 3.69
567771 | 1D34 | 0.328084 | 1.31152 | 1.31234 | 89.9642 | 200ø-200ø |  | 3100 | Level 1 | Level : Level 1 | 3.3
567742 | 1DC7 | 0.246063 | 0.984252 | 0.984252 | 90 | 150ø-150ø | CD3-11 | 2991 | Level 1 | Level : Level 1 | 3.35
570564 | 1EC1 | 0.574147 | 2.29659 | 2.29659 | 90 | 350ø-350ø | CD3-11 | 90 | Level 2 | Level : Level 2 | -1.17
567532 | 1B17 | 0.328084 | 0.543587 | 1.31234 | 45 | 200ø-200ø | CD3-17 | 2330 | Level 1 | Level : Level 1 | 3.49042
567703 | 1D38 | 0.574147 | 0.951278 | 2.29659 | 45 | 350ø-350ø | CD3-17 | 2906 | Level 1 | Level : Level 1 | 3.69
567767 | 1D34 | 0.328084 | 0.543587 | 1.31234 | 45 | 200ø-200ø | CD3-17 | 3094 | Level 1 | Level : Level 1 | 3.79
567964 | 1A01 | 0.246063 | 0.984252 | 0.984252 | 90 | 150ø-150ø | CD3-11 | 3747 | Level 2 | Level : Level 2 | -0.860492
568091 | 1CC3 | 0.410105 | 1.64042 | 1.64042 | 90 | 250ø-250ø | CD3-11 | 4155 | Level 2 | Level : Level 2 | -1.32
567641 | 1D25 | 0.328084 | 0.26104 | 1.31234 | 22.5 | 200ø-200ø |  | 2663 | Level 1 | Level : Level 1 | 3.3994
1119660 | 1E11 | 0.574147 | 0.467252 | 2.29659 | 23.0003 | 350ø-350ø |  | 1015 | Level 1 | Level : Level 1 | 3.69
567972 | 1A02 | 0.328084 | 1.31234 | 1.31234 | 90 | 200ø-200ø | CD3-11 | 3760 | Level 2 | Level : Level 2 | -0.860494
567547 | 1B13 | 0.328084 | 1.31234 | 1.31234 | 90 | 200ø-200ø | CD3-11 | 2360 | Level 1 | Level : Level 1 | 3.79951
568079 | 1C09 | 0.246063 | 0.984252 | 0.984252 | 90 | 150ø-150ø | CD3-11 | 4110 | Level 2 | Level : Level 2 | -1.21052
567379 | 1E04 | 0.328084 | 0.543643 | 1.31234 | 45.0041 | 200ø-200ø |  | 1818 | Level 1 | Level : Level 1 | 3.30001
568018 | 1AC3 | 0.328084 | 1.31234 | 1.31234 | 90 | 200ø-200ø | CD3-11 | 3949 | Level 2 | Level : Level 2 | -0.87
567843 | 1EC1 | 0.492126 | 1.9685 | 1.9685 | 90 | 300ø-300ø | CD3-11 | 3293 | Level 1 | Level : Level 1 | 3.4
570572 | 1A05 | 0.410105 | 1.64042 | 1.64042 | 90 | 250ø-250ø | CD3-11 | 103 | Level 2 | Level : Level 2 | -0.860486
567806 | 1DC7 | 0.246063 | 0.54603 | 0.984252 | 58.0401 | 150ø-150ø |  | 3164 | Level 1 | Level : Level 1 | 3.3095
568071 | 1C09 | 0.246063 | 0.984252 | 0.984252 | 90 | 150ø-150ø | CD3-11 | 4084 | Level 2 | Level : Level 2 | -1.2105
567741 | 1DC7 | 0.246063 | 0.984252 | 0.984252 | 90 | 150ø-150ø | CD3-11 | 2990 | Level 1 | Level : Level 1 | 3.3
567718 | 1BC4 | 0.410105 | 1.64042 | 1.64042 | 90 | 250ø-250ø | CD3-11 | 2945 | Level 1 | Level : Level 1 | 3.69
567622 | 1D25 | 0.410105 | 1.64042 | 1.64042 | 90 | 250ø-250ø | CD3-11 | 2616 | Level 1 | Level : Level 1 | 3.28098
570570 | 1A12 | 0.246063 | 0.984252 | 0.984252 | 90 | 150ø-150ø | CD3-11 | 98 | Level 2 | Level : Level 2 | -0.8355
1120723 | 1BC2 | 0.328084 | 0.543587 | 1.31234 | 45 | 200ø-200ø | CD3-17 | 1130 | Level 1 | Level : Level 1 | 3.36043
568170 | 1CC1 | 0.328084 | 1.31234 | 1.31234 | 90 | 200ø-200ø | CD3-11 | 4403 | Level 2 | Level : Level 2 | -1.27
567768 | 1D34 | 0.328084 | 0.543587 | 1.31234 | 45 | 200ø-200ø | CD3-17 | 3096 | Level 1 | Level : Level 1 | 3.3
1120953 | 1A16 | 0.328084 | 1.31234 | 1.31234 | 90.0002 | 200ø-200ø |  | 1144 | Level 1 | Level : Level 1 | 3.7095
567529 | 1B17 | 0.328084 | 1.31234 | 1.31234 | 90 | 200ø-200ø | CD3-11 | 2325 | Level 1 | Level : Level 1 | 3.5
567856 | 1E18 | 0.246063 | 0.479655 | 0.984252 | 51.9626 | 150ø-150ø |  | 3353 | Level 1 | Level : Level 1 | 3.4146
567857 | 1E18 | 0.246063 | 0.479655 | 0.984252 | 51.9626 | 150ø-150ø |  | 3360 | Level 1 | Level : Level 1 | 3.4146
567795 | 1D32 | 0.328084 | 0.543587 | 1.31234 | 45 | 200ø-200ø | CD3-17 | 3149 | Level 1 | Level : Level 1 | 3.3095
1112308 | 1D24 | 0.328084 | 1.31234 | 1.31234 | 90 | 200ø-200ø | CD3-11 | 620 | Level 1 | Level : Level 1 | 3.2
568007 | 1A16 | 0.410105 | 1.64042 | 1.64042 | 90 | 250ø-250ø | CD3-11 | 3895 | Level 2 | Level : Level 2 | -0.87
568030 | 1AC4 | 0.246063 | 0.984252 | 0.984252 | 90 | 150ø-150ø | CD3-11 | 4019 | Level 2 | Level : Level 2 | -1.07
568041 | Level 1 | 0.246063 | 0.984252 | 0.984252 | 90 | 150ø-150ø | CD3-11 | 4036 | Level 2 | Level : Level 2 | -0.87
567805 | 1D33 | 0.246063 | 0.984252 | 0.984252 | 90 | 150ø-150ø | CD3-11 | 3163 | Level 1 | Level : Level 1 | 3.3095
570701 | 1D38 | 0.410105 | 0.679484 | 1.64042 | 45 | 250ø-250ø | CD3-17 | 529 | Level 1 | Level : Level 1 | 3.69
567884 | 1EC1 | 0.246063 | 0.984252 | 0.984252 | 90 | 150ø-150ø | CD3-11 | 3412 | Level 1 | Level : Level 1 | 3.4095
567644 | 1D25 | 0.328084 | 0.26104 | 1.31234 | 22.5 | 200ø-200ø |  | 2675 | Level 1 | Level : Level 1 | 3.26046
567794 | 1D32 | 0.328084 | 0.543587 | 1.31234 | 45 | 200ø-200ø | CD3-17 | 3147 | Level 1 | Level : Level 1 | 3.79

# IfcFlowFitting: 380 mm Strainer - 100 mm Drain (4)
In: 3R01
Type - ElementType: 380 mm Strainer - 100 mm Drain; PredefinedType: ENTRY
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Storm
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - Schedule Level: Level 1; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Host: <not associated>
PSet_Revit_Type_Dimensions - Pipe Radius: 0.164042; Pipe Diameter: 0.328084; Overall Radius: 0.075 m; Overall Diameter: 0.15 m
PSet_Revit_Type_Constraints - Default Elevation: 0 m
PSet_Revit_Type_Identity Data - OmniClass Number: 23.70.50.24.17; OmniClass Title: Siphonic Drains
Name (M_Roof Drain:380 mm Strainer - 100 mm Drain:380 mm Strainer - 100 mm Drain:...) | TagNumber = Mark | Elevation (m) | Offset (m)
727511 | OD | 9.30396 | -0.0460375
727559 | OD | 9.30396 | -0.0460375
727571 | RD | 9.35 | 0
727522 | RD | 9.35 | 0

# IfcFlowFitting: 380 mm Strainer - 150 mm Drain (10)
Type - ElementType: 380 mm Strainer - 150 mm Drain; PredefinedType: ENTRY
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Sanitary
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.70.50.24.17; OmniClass Title: Siphonic Drains
PSet_Revit_Type_Dimensions - Pipe Radius: 0.246063; Pipe Diameter: 0.492126; Overall Radius: 0.075 m; Overall Diameter: 0.15 m
PSet_Revit_Type_Constraints - Default Elevation: 0 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Roof Drain:380 mm Strainer - 150 mm Drain:380 mm Strainer - 150 mm Drain:...) | In | Mark = TagNumber | Schedule Level | Host | Elevation (m) | Offset (m) | System Name
726998 | 3R01 | RD | Roof - Main | <not associated> | 0.1 | 0 | Storm
726902 | 3R01 | OD | Level 1 | <not associated> | 9.30396 | -0.0460375 | Storm
727419 | 2R02 | OD | Level 1 | Pipe Types : Storm | 4.57 | 0 | Storm
1151076 | 2R02 | OD | Level 1 | Pipe Types : Storm | 4.57 | 0 | Default Sanitary (cskender)
727430 | 2R02 | RD | Level 1 | <not associated> | 4.57 | 0 | Storm
727375 | 3R01 | OD | Level 1 | <not associated> | 9.30396 | -0.0460375 | Storm
1074854 | 2R02 | RD | Level 2 | <not associated> | 0 | 0 | Storm
727363 | 3R01 | RD | Level 1 | <not associated> | 9.30396 | -0.0460375 | Storm
1150681 | 3R01 | RD | Level 1 | <not associated> | 9.35 | 0 | Default Sanitary (cskender)
1150739 | 3R01 | OD | Level 1 | <not associated> | 9.30396 | -0.0460375 | Default Sanitary (cskender)

# IfcFlowFitting: 380 mm Strainer - 25 mm Drain (16)
Type - ElementType: 380 mm Strainer - 25 mm Drain; PredefinedType: ENTRY
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Storm
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Dimensions - Pipe Radius: 0.131234; Pipe Diameter: 0.262467; Overall Radius: 0.075 m; Overall Diameter: 0.15 m
PSet_Revit_Type_Constraints - Default Elevation: 0 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.70.50.24.17; OmniClass Title: Siphonic Drains
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Roof Drain:380 mm Strainer - 25 mm Drain:380 mm Strainer - 25 mm Drain:...) | In | Schedule Level | TagNumber = Mark | Host | Elevation (m) | Offset (m)
727023 | 2R01 | Roof - Main | OD | Pipe Types : Storm | -4.68 | 0
727035 | 2R01 | Roof - Main | RD | Pipe Types : Storm | -4.68 | 0
727487 | 2R02 | Level 1 | OD | Pipe Types : Storm | 4.57 | 0
1074188 | 2R02 | Level 2 | RD | Pipe Types : Storm | 0 | 0
1088355 | 3R01 | Roof - Main | OD | Linked Revit Model : Clinic_S.rvt | 0.0739625 | -0.0460375
1074177 | 2R02 | Level 2 | OD | Pipe Types : Storm | 0 | 0
1088589 | 3R01 | Roof - Main | RD | Linked Revit Model : Clinic_S.rvt | 0.12 | 0
727476 | 2R02 | Level 1 | RD | Pipe Types : Storm | 4.57 | 0
727209 | 3R03 | Level 1 | OD | <not associated> | 6.72396 | -0.0460375
727184 | 3R03 | Level 1 | RD | <not associated> | 6.72396 | -0.0460375
1087018 | 3R04 | Level 1 | RD | Linked Revit Model : Clinic_S.rvt | 8.01046 | -0.0460375
1087064 | 3R04 | Level 1 | OD | Linked Revit Model : Clinic_S.rvt | 8.01046 | -0.0460375
1087444 | 3R02 | Level 1 | RD | Linked Revit Model : Clinic_S.rvt | 8.0565 | 0
1087343 | 3R03 | Level 1 | RD | <not associated> | 6.72396 | -0.0460375
1087332 | 3R03 | Level 1 | OD | <not associated> | 6.72396 | -0.0460375
1087420 | 3R02 | Level 1 | OD | Linked Revit Model : Clinic_S.rvt | 8.0565 | 0

# IfcFlowFitting: 45 Degree (707)
Type - ElementType: 45 Degree
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Mechanical - Lining Thickness: 0; Insulation Thickness: 0; Loss Method: 1
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
PSet_Revit_Type_Constraints - Angle: 45 deg
Name | In | Length 2 | Length 1 | Mark | System Type | System Name | ASHRAE Table | Level | Host | Offset (m) | Size | OffsetHeight | OffsetWidth | Num8 | Num7 | Num6 | Num5 | Num4 | Num3 | Num2 | Num1 | PSet_Revit_Other, Delta 2 | PSet_Revit_Other, Delta 1 | WidthOffset | WidthDelta | Width2 = Lining Width 2 = Insulation Width 2 | Width1 = Lining Width 1 = Insulation Width 1 | MaxDelta = Length 01 = Computed Length | Lining Height 2 = Insulation Height 2 = Height2 | Lining Height 1 = Insulation Height 1 = Height1 | HeightOffset | HeightDelta | Half Width 2 | Half Width 1 | Half Height 2 | Half Height 1
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568743 | 1D05 | 0.082021 | 0.082021 | 5559 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570326 | 2BC4 | 0.164042 | 0.164042 | 8895 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:569913 | Level 2 | 0.198016 | 0.198016 | 8204 | Supply Air | Default Supply Air (cskender) | SR4-1 | Roof - Main | Level : Roof - Main | -1.32048 | 250x200-200x200 | 0.32792 | 0.410105 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0.000164042 | 0 | 10 | 0.164042 | 0.656168 | 0.82021 | 0.198016 | 0.656168 | 0.656168 | 9.99984 | 0 | 0.328084 | 0.410105 | 0.328084 | 0.328084
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568740 | 1D08 | 0.164042 | 0.164042 | 5556 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570352 | 2D20 | 0.082021 | 0.082021 | 8909 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568752 | 1A10 | 0.164042 | 0.164042 | 5564 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568634 | 1DC1 | 0.164042 | 0.164042 | 5483 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568738 | 1D31 | 0.164042 | 0.164042 | 5547 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568733 | 1B13 | 0.164042 | 0.164042 | 5544 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568735 | 1DC8 | 0.164042 | 0.164042 | 5545 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Round Transition - Angle:45 Degree:45 Degree:569530 | 2BC3 | 0.082021 | 0.082021 | 7212 | Supply Air | Mechanical Supply Air 2 | SD4-1 | Roof - Main | Level : Roof - Main | -1.08 | 250ø-200ø | 0.410105 | 0.410105 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0341754; OffsetHeightTemp: 0.0341754; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.328084; R0: 0.410105; Lining Radius 1: 0.328084; Lining Radius 0: 0.410105; Insulation Radius 1: 0.328084; Insulation Radius 0: 0.410105; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570337 | 2B14 | 0.164042 | 0.164042 | 8901 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570316 | 2B7 | 0.164042 | 0.164042 | 8889 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Round Transition - Angle:45 Degree:45 Degree:569561 | 2BC5 | 0.164042 | 0.164042 | 7293 | Supply Air | Mechanical Supply Air 2 | SD4-1 | Roof - Main | Level : Roof - Main | -1.08 | 300ø-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 1: 1.9685; Num 5: 4.75239; Num 4: 1; Num 3: 3.93701; Num 2: 1.9685; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0410105; OffsetHeightTemp: 0.0410105; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.164042; R1: 0.328084; R0: 0.492126; Lining Radius 1: 0.328084; Lining Radius 0: 0.492126; Insulation Radius 1: 0.328084; Insulation Radius 0: 0.492126; HeightOffsetfromBase: 10; ComputedLength: 0.396032
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568745 | 1C07 | 0.164042 | 0.164042 | 5560 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Round Transition - Angle:45 Degree:45 Degree:569582 | 2D18 | 0.082021 | 0.082021 | 7362 | Supply Air | Mechanical Supply Air 2 | SD4-1 | Roof - Main | Level : Roof - Main | -1.08 | 350ø-300ø | 0.574147 | 0.574147 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0478456; OffsetHeightTemp: 0.0478456; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.492126; R0: 0.574147; Lining Radius 1: 0.492126; Lining Radius 0: 0.574147; Insulation Radius 1: 0.492126; Insulation Radius 0: 0.574147; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570304 | 2B01 | 0.082021 | 0.082021 | 8883 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570321 | 2B8 | 0.164042 | 0.164042 | 8892 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:569417 | 2A14 | 0.396032 | 0.198016 | 6840 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.0705 | 250x250-150x250 | 0.410105 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.82021 | 0.82021 | 10 | 0 | 0.246063 | 0.410105 | 0.410105 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568599 | 1C18 | 0.164042 | 0.164042 | 5459 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570370 | 2D04 | 0.164042 | 0.164042 | 8919 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568597 | 1C18 | 0.164042 | 0.164042 | 5458 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570306 | 2BC5 | 0.082021 | 0.082021 | 8884 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570362 | 2D04-A | 0 | 0 | 8915 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-300ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 0; Num 7: 0; Num 6: 0; Num 10: 0; Num 1: 0; Length 8: 0; Length 7: 0; Length 6: 0; Length 5: 0; Length 4: 0; Half H0: 0.492126; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0; Delta 1: 0; W0: 0.984252; Radius: 0.492126; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.492126; Lining H0: 0.984252; Length01: 0.246063; Insulation W0: 0.984252; Insulation Radius: 0.492126; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.984252
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568623 | 1D15 | 0.246063 | 0.246063 | 5475 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568725 | 1B15 | 0.164042 | 0.164042 | 5540 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568731 | 1B13 | 0.164042 | 0.164042 | 5543 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568748 | 1A14 | 0.246063 | 0.246063 | 5562 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570394 | 2D18 | 0.246063 | 0.246063 | 8932 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568629 | 1DC1 | 0.164042 | 0.164042 | 5480 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570302 | 2AC4 | 0.246063 | 0.246063 | 8882 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568727 | 1B03 | 0.164042 | 0.164042 | 5541 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:569900 | 2BC6 | 0.246063 | 0.246063 | 8190 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
