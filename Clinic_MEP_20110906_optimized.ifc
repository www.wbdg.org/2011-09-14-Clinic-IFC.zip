Properties of the parts of a building model (IFC2X3), part 3 of 295

# IfcSpace (526)
Name | In | LongName = Name | Area (m2) = GSA BIM Area (m2) | Perimeter (m) | Unbounded Height (m) | Volume (m3) | Level | Upper Limit | Limit Offset (m) | Base Offset (m) | Category Description | Category Code | CirculationZoneName | FireAlarmZoneName | HistoricPreservationZoneName | LightingZoneName | OccupancyZoneName | VentilationZoneName | Number | OmniClass Table 13 Category | RoomTag
2B01-M | Level 2 | OFFICE | 8.59779 | 12.222 | 4 | 34.3912 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B01-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.81623; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B01; Room Name: OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E07-M | Level 1 | CONF. LIBRARY | 10.7998 | 13.156 | 4 | 43.1993 | Level 1 | Level 1 | 4 | 0 | Conference Room | 13-11 21 17 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E07-M | 13-11 21 17: Conference Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.84111; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E07; Room Name: CONF. LIBRARY; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2A12-A-M | Level 2 | X-RAY ALCOVE | 1.99558 | 5.5678 | 4 | 7.98231 | Level 2 | Level 2 | 4 | 0 | Scanning/Imaging Room | 13-41 41 31 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A12-A-M | 13-41 41 31: Scanning/Imaging Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 13.3784; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2A12-A; Room Name: X-RAY ALCOVE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B11-M | Level 1 | STAFF TOILET | 4.41043 | 8.456 | 4 | 17.6417 | Level 1 | Level 1 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B11-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 9.19332; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B11; Room Name: STAFF TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1C08-M | Level 1 | SCREEN EYE TEST | 9.09866 | 12.856 | 4 | 36.3946 | Level 1 | Level 1 | 4 | 0 | Physical Examination Room | 13-41 41 14 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C08-M | 13-41 41 14: Physical Examination Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.77512; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C08; Room Name: SCREEN EYE TEST; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E23-M | Level 1 | BEE EQUIP. STORAGE | 8.05483 | 12.5072 | 4 | 32.2193 | Level 1 | Level 1 | 4 | 0 | Equipment Room | 13-81 21 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E23-M | 13-81 21 11: Equipment Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.44548; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E23; Room Name: BEE EQUIP. STORAGE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1EC4-M | Level 1 | CORRIDOR | 8.46339 | 13.024 | 4 | 33.8536 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1EC4-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.37885; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1EC4; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2A09-M | Level 2 | GEN. DENT. DTR #5 | 10.4892 | 11.4977 | 4 | 41.9567 | Level 2 | Level 2 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A09-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.25603; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2A09; Room Name: GEN. DENT. DTR #5; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1DC4-M | Level 1 | CORRIDOR | 14.1002 | 20.167 | 4 | 56.4006 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1DC4-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.85814; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1DC4; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D11-M | Level 1 | INTERACTION STATION | 11.8747 | 14.283 | 4 | 47.4986 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D11-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.76749; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D11; Room Name: INTERACTION STATION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B16-M | Level 1 | JAN. CL. | 3.42762 | 7.97 | 4 | 13.7105 | Level 1 | Level 1 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B16-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 11.1495; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B16; Room Name: JAN. CL.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B23-M | Level 1 | ELEC. ROOM | 9.08738 | 12.5841 | 4 | 36.3495 | Level 1 | Level 1 | 4 | 0 | Electrical Room | 13-81 21 21 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B23-M | 13-81 21 21: Electrical Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.64004; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B23; Room Name: ELEC. ROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1AC1-M | Level 1 | CENTRAL WAITING | 136.827 | 70.1081 | 4 | 547.31 | Level 1 | Level 1 | 4 | 0 | Waiting Room | 13-51 31 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1AC1-M | 13-51 31 11: Waiting Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 49.7937; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 2.95188; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1AC1; Room Name: CENTRAL WAITING; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B22-M | Level 2 | M. TOILET | 4.44035 | 8.43644 | 4 | 17.7614 | Level 2 | Level 2 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B22-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 9.11026; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B22; Room Name: M. TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D35-M | Level 1 | INTERACTION STATION | 11.9464 | 13.936 | 4 | 47.7857 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D35-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.59357; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D35; Room Name: INTERACTION STATION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1CC1-M | Level 1 | CORRIDOR | 40.2345 | 49.565 | 4 | 160.938 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1CC1-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.90698; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1CC1; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1C01-M | Level 1 | WAITING | 11.6366 | 13.677 | 4 | 46.5464 | Level 1 | Level 1 | 4 | 0 | Waiting Room | 13-51 31 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C01-M | 13-51 31 11: Waiting Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.63577; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C01; Room Name: WAITING; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D39-M | Level 1 | JAN. CL. | 1.66144 | 5.696 | 4 | 6.64574 | Level 1 | Level 1 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D39-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 16.439; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D39; Room Name: JAN. CL.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D22-M | Level 1 | TEAM INTERACTION | 23.2185 | 20.533 | 4 | 92.8738 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D22-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.24041; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D22; Room Name: TEAM INTERACTION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1CC2-M | Level 1 | CORRIDOR | 7.56949 | 12.2732 | 4 | 30.2779 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1CC2-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.77464; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1CC2; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C24-M | Level 2 | W. TOILET | 8.49626 | 11.6642 | 4 | 33.985 | Level 2 | Level 2 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C24-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.58286; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C24; Room Name: W. TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C02-M | Level 2 | GEN. DENT. DTR #6 | 11.1079 | 11.3912 | 4 | 44.4316 | Level 2 | Level 2 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C02-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.91727; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C02; Room Name: GEN. DENT. DTR #6; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B9-M | Level 2 | TECH OFFICE | 9.16922 | 12.184 | 4 | 36.6769 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B9-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.37157; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B9; Room Name: TECH OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2CS3-M | Level 2 | STAIR | 14.2045 | 16.872 | 4 | 56.8179 | Level 2 | Level 2 | 4 | 0 | Stairway | 13-85 21 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2CS3-M | 13-85 21 11: Stairway | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 0; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2CS3; Room Name: STAIR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2A11-M | Level 2 | DENTAL WAITING | 31.8444 | 28.5553 | 4 | 127.378 | Level 2 | Level 2 | 4 | 0 | Waiting Room | 13-51 31 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A11-M | 13-51 31 11: Waiting Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 24.8968; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.29973; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2A11; Room Name: DENTAL WAITING; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B21-M | Level 1 | COMM. ROOM | 9.01095 | 12.516 | 4 | 36.0438 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B21-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.66014; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B21; Room Name: COMM. ROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E28-M | Level 1 | FAC. MGR. OFFICE | 8.62789 | 11.3634 | 4 | 34.5116 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E28-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.3153; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E28; Room Name: FAC. MGR. OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1A16-M | Level 1 | PHARM. DISP. | 65.2247 | 42.206 | 4 | 260.899 | Level 1 | Level 1 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A16-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 33.1958; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 3.10278; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1A16; Room Name: PHARM. DISP.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
E1M | Level 1 | ELEVATOR | 3.93734 | 7.03528 | 9.25 | 36.4204 | Level 1 | Roof - Main | 0 | 0 | Elevator Shaft | 13-81 21 31 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | E1M | 13-81 21 31: Elevator Shaft | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 0; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: E1; Room Name: ELEVATOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1C04-M | Level 1 | FITTING / DISP. | 9.19069 | 12.29 | 4 | 36.7627 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C04-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.41199; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C04; Room Name: FITTING / DISP.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D06-M | Level 1 | SCOPE WASH / DECON. | 8.31551 | 12.151 | 4 | 33.262 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D06-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.00667; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D06; Room Name: SCOPE WASH / DECON.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C04-M | Level 2 | GEN. DENT. DTR #7 | 10.3228 | 11.4335 | 4 | 41.2913 | Level 2 | Level 2 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C04-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.31091; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C04; Room Name: GEN. DENT. DTR #7; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B07-M | Level 1 | DRESS | 3.8971 | 8.208 | 4 | 15.5884 | Level 1 | Level 1 | 4 | 0 | Dressing Room | 13-41 11 41 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B07-M | 13-41 11 41 11: Dressing Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 10.0991; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B07; Room Name: DRESS; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D13-M | Level 1 | INTERACTION STATION | 11.9464 | 13.936 | 4 | 47.7856 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D13-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.59357; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D13; Room Name: INTERACTION STATION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B7-M | Level 2 | TECH OFFICE | 9.23674 | 12.259 | 4 | 36.9469 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B7-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.36393; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B7; Room Name: TECH OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2A13-M | Level 2 | DEVELOPING | 6.88503 | 11.282 | 4 | 27.5401 | Level 2 | Level 2 | 4 | 0 | Scanning/Imaging Room | 13-41 41 31 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A13-M | 13-41 41 31: Scanning/Imaging Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.85722; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2A13; Room Name: DEVELOPING; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2BC1-M | Level 2 | CORRIDOR | 12.1506 | 15.44 | 4 | 48.6023 | Level 2 | Level 2 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2BC1-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.09311; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2BC1; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2A12-M | Level 2 | X-RAY | 10.3428 | 13.8449 | 4 | 41.3713 | Level 2 | Level 2 | 4 | 0 | Scanning/Imaging Room | 13-41 41 31 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A12-M | 13-41 41 31: Scanning/Imaging Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.4186; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2A12; Room Name: X-RAY; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2A10-M | Level 2 | DENTAL WAITING | 7.30491 | 10.7341 | 4 | 29.2196 | Level 2 | Level 2 | 4 | 0 | Waiting Room | 13-51 31 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A10-M | 13-51 31 11: Waiting Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.04595; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2A10; Room Name: DENTAL WAITING; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C22-M | Level 2 | LOUNGE | 10.3241 | 13.3083 | 4 | 41.2963 | Level 2 | Level 2 | 4 | 0 | Break Room | 13-51 11 21 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C22-M | 13-51 11 21: Break Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.18101; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C22; Room Name: LOUNGE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B14-M | Level 2 | RECS / FORMS STORAGE | 9.75662 | 13.108 | 4 | 39.0265 | Level 2 | Level 2 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B14-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.44207; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B14; Room Name: RECS / FORMS STORAGE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2CC4-M | Level 2 | CORRIDOR | 10.0491 | 14.502 | 4 | 40.1964 | Level 2 | Level 2 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2CC4-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.91973; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2CC4; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2BC2-M | Level 2 | CORRIDOR | 27.5913 | 31.9709 | 4 | 110.365 | Level 2 | Level 2 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2BC2-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.55611; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2BC2; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D33-M | Level 1 | PEDIATRIC WAITING | 11.8826 | 13.936 | 4 | 47.5303 | Level 1 | Level 1 | 4 | 0 | Waiting Room | 13-51 31 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D33-M | 13-51 31 11: Waiting Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.62362; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D33; Room Name: PEDIATRIC WAITING; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1DC2-M | Level 1 | CORRIDOR | 5.9337 | 10.422 | 4 | 23.7348 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1DC2-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 8.42198; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1DC2; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D09-M | Level 1 | INTERACTION STATION | 11.9464 | 13.971 | 4 | 47.7856 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D09-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.60762; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D09; Room Name: INTERACTION STATION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E04-M | Level 1 | HK BREAK ROOM | 8.97631 | 11.996 | 4 | 35.9052 | Level 1 | Level 1 | 4 | 0 | Break Room | 13-51 11 21 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E04-M | 13-51 11 21: Break Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.40807; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E04; Room Name: HK BREAK ROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2A04-M | Level 2 | DENTAL SURGEON OFFICE | 14.9321 | 15.53 | 4 | 59.7282 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A04-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.98701; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2A04; Room Name: DENTAL SURGEON OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D17-M | Level 2 | CREDENTIALS MGR | 8.69774 | 12.1189 | 4 | 34.791 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D17-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.68105; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D17; Room Name: CREDENTIALS MGR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2AC1-A-M | Level 2 | OPEN TO BELOW | 65.8937 | 37.5643 | 4 | 263.575 | Level 2 | Level 2 | 4 | 0 | Other Transitional Circulation Spaces | 13-85 31 99 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2AC1-A-M | 13-85 31 99: Other Transitional Circulation Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 0; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2AC1-A; Room Name: OPEN TO BELOW; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E10-M | Level 1 | M. TOILET | 4.4482 | 8.666 | 4 | 17.7928 | Level 1 | Level 1 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E10-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 9.34163; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E10; Room Name: M. TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2AC5-M | Level 2 | CORRIDOR | 8.38071 | 13.222 | 4 | 33.5228 | Level 2 | Level 2 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2AC5-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.56493; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2AC5; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E33-M | Level 1 | ISOLATION INTERACTION STATION | 12.4557 | 14.532 | 4 | 49.823 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E33-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.59428; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E33; Room Name: ISOLATION INTERACTION STATION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1CS3-M | Level 1 | STAIR | 12.7547 | 18.376 | 4 | 51.019 | Level 1 | Level 1 | 4 | 0 | Stairway | 13-85 21 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1CS3-M | 13-85 21 11: Stairway | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 0; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1CS3; Room Name: STAIR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B17-M | Level 1 | TECH. WORK ROOM | 23.0367 | 19.6861 | 4 | 92.1467 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B17-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.09758; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B17; Room Name: TECH. WORK ROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1AC4-M | Level 1 | CORRIDOR | 8.79966 | 13.712 | 4 | 35.1986 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1AC4-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.47177; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1AC4; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
