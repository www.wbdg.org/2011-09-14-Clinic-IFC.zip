Properties of the parts of a building model (IFC2X3), part 57 of 295

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:995644
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 9.13632; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.281886; Hydraulic Diameter: 0.492126; Section: 334; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 2.10063 m
PSet_Revit_Identity Data - Mark: 8
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:995646
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:995646
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.15973 m
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.155625; Hydraulic Diameter: 0.492126; Section: 345; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 5.04401; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Identity Data - Mark: 9
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:995699
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:995699
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 30
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.139019; Hydraulic Diameter: 0.492126; Section: 346; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 4.50581; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.03598 m
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:998454
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:998454
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.06497; Hydraulic Diameter: 0.492126; Section: 2; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.484161 m
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 33
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 2.10577; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:998457
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:998457
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 34
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.152401; Hydraulic Diameter: 0.492126; Section: 8; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.1357 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 4.93954; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:998462
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:998462
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Identity Data - Mark: 40
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.115186; Hydraulic Diameter: 0.492126; Section: 22; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 3.73332; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.858371 m
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:998465
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:998465
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.107556; Hydraulic Diameter: 0.492126; Section: 31; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Identity Data - Mark: 46
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.801512 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 3.48603; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:1111909
In: Level 1
Type - ElementType: Oval Duct:Gored Elbows / Tees:1111909
PSet_Revit_Mechanical - Airflow - Flow: 60.0349; Additional Flow: 0; Velocity: 42.6781; Friction: 0.396024; Pressure Drop: 3.46678; Velocity Pressure: 31.0132; Reynolds number: 337506
PSet_Revit_Identity Data - Mark: 505
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.05 m; Top Elevation: 3.35 m; Equivalent Diameter: 1.32429; Size Lock: no; Loss Coefficient: 0.111784; Hydraulic Diameter: 1.27752; Section: 198; Insulation Thickness: 0; Lining Thickness: 0; Area: 3.58201 m2
PSet_Revit_Dimensions - Size: 500/300; Width: 1.64042; Height: 0.984252; Length: 2.66821 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.2 m; Start Offset: 3.2 m; End Offset: 3.2 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:1111920
In: Level 1
Type - ElementType: Oval Duct:Gored Elbows / Tees:1111920
PSet_Revit_Identity Data - Mark: 512
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.13078 m; Top Elevation: 3.56922 m; Equivalent Diameter: 1.32429; Size Lock: no; Loss Coefficient: 0.0149667; Hydraulic Diameter: 1.27752; Section: 198; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.479594 m2
PSet_Revit_Dimensions - Size: 500/300; Width: 1.64042; Height: 0.984252; Length: 0.357246 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.43931 m; Start Offset: 3.43931 m; End Offset: 3.26069 m; Slope: 0.57735
PSet_Revit_Mechanical - Airflow - Flow: 60.0349; Additional Flow: 0; Velocity: 42.6781; Friction: 0.396024; Pressure Drop: 0.464166; Velocity Pressure: 31.0132; Reynolds number: 337506
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:567888
In: Level 1
Type - ElementType: Oval Duct:Gored Elbows / Tees:567888
PSet_Revit_Identity Data - Mark: 696
PSet_Revit_Dimensions - Size: 900/500; Width: 2.95276; Height: 1.64042; Length: 1.00236 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.45 m; Top Elevation: 3.95 m; Equivalent Diameter: 2.29822; Size Lock: no; Loss Coefficient: 0.0214865; Hydraulic Diameter: 2.19396; Section: 41; Insulation Thickness: 0; Lining Thickness: 0; Area: 2.37638 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 225.131; Additional Flow: 0; Velocity: 52.77; Friction: 0.309791; Pressure Drop: 1.01877; Velocity Pressure: 47.4144; Reynolds number: 716680
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.7 m; Start Offset: 3.7 m; End Offset: 3.7 m; Slope: 0
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:567890
In: Level 1
Type - ElementType: Oval Duct:Gored Elbows / Tees:567890
PSet_Revit_Mechanical - Airflow - Flow: 225.131; Additional Flow: 0; Velocity: 52.77; Friction: 0.309791; Pressure Drop: 2.3115; Velocity Pressure: 47.4144; Reynolds number: 716680
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.7 m; Start Offset: 3.7 m; End Offset: 3.7 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.45 m; Top Elevation: 3.95 m; Equivalent Diameter: 2.29822; Size Lock: no; Loss Coefficient: 0.048751; Hydraulic Diameter: 2.19396; Section: 41; Insulation Thickness: 0; Lining Thickness: 0; Area: 5.3918 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 900/500; Width: 2.95276; Height: 1.64042; Length: 2.27425 m
PSet_Revit_Identity Data - Mark: 697
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:567892
In: Level 1
Type - ElementType: Oval Duct:Gored Elbows / Tees:567892
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 699
PSet_Revit_Mechanical - Airflow - Flow: 165.096; Additional Flow: 0; Velocity: 51.7562; Friction: 0.33902; Pressure Drop: 22.6903; Velocity Pressure: 45.6101; Reynolds number: 632236
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.45 m; Top Elevation: 3.95 m; Equivalent Diameter: 2.00694; Size Lock: no; Loss Coefficient: 0.497485; Hydraulic Diameter: 1.97337; Section: 60; Insulation Thickness: 0; Lining Thickness: 0; Area: 40.2042 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.7 m; Start Offset: 3.7 m; End Offset: 3.7 m; Slope: 0
PSet_Revit_Dimensions - Size: 700/500; Width: 2.29659; Height: 1.64042; Length: 20.4 m
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:567894
In: Level 1
Type - ElementType: Oval Duct:Gored Elbows / Tees:567894
PSet_Revit_Dimensions - Size: 700/500; Width: 2.29659; Height: 1.64042; Length: 3.36973 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.7 m; Start Offset: 3.7 m; End Offset: 3.7 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.45 m; Top Elevation: 3.95 m; Equivalent Diameter: 2.00694; Size Lock: no; Loss Coefficient: 0.0836564; Hydraulic Diameter: 1.97337; Section: 59; Insulation Thickness: 0; Lining Thickness: 0; Area: 6.64106 m2
PSet_Revit_Mechanical - Airflow - Flow: 135.079; Additional Flow: 0; Velocity: 42.346; Friction: 0.231036; Pressure Drop: 2.55423; Velocity Pressure: 30.5324; Reynolds number: 517284
PSet_Revit_Identity Data - Mark: 701
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:568080
In: Level 1
Type - ElementType: Oval Duct:Gored Elbows / Tees:568080
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.25 m; Start Offset: 3.25 m; End Offset: 3.25 m; Slope: 0
PSet_Revit_Identity Data - Mark: 843
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 105.061; Additional Flow: 0; Velocity: 74.6867; Friction: 1.15893; Pressure Drop: 21.929; Velocity Pressure: 94.978; Reynolds number: 590635
PSet_Revit_Dimensions - Size: 500/300; Width: 1.64042; Height: 0.984252; Length: 5.76733 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.1 m; Top Elevation: 3.4 m; Equivalent Diameter: 1.32429; Size Lock: no; Loss Coefficient: 0.230885; Hydraulic Diameter: 1.27752; Section: 15; Insulation Thickness: 0; Lining Thickness: 0; Area: 7.74251 m2
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:568083
In: Level 1
Type - ElementType: Oval Duct:Gored Elbows / Tees:568083
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.45 m; Top Elevation: 3.95 m; Equivalent Diameter: 2.29822; Size Lock: no; Loss Coefficient: 0.0550333; Hydraulic Diameter: 2.19396; Section: 17; Insulation Thickness: 0; Lining Thickness: 0; Area: 6.27703 m2
PSet_Revit_Dimensions - Size: 900/500; Width: 2.95276; Height: 1.64042; Length: 2.64764 m
PSet_Revit_Identity Data - Mark: 844
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.7 m; Start Offset: 3.7 m; End Offset: 3.7 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 345.201; Additional Flow: 0; Velocity: 80.914; Friction: 0.706258; Pressure Drop: 6.13491; Velocity Pressure: 111.476; Reynolds number: 1098909
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:568084
In: Level 1
Type - ElementType: Oval Duct:Gored Elbows / Tees:568084
PSet_Revit_Identity Data - Mark: 845
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.55 m; Top Elevation: 3.85 m; Equivalent Diameter: 1.32429; Size Lock: no; Loss Coefficient: 0.0375042; Hydraulic Diameter: 1.27752; Section: 16; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.26854 m2
PSet_Revit_Mechanical - Airflow - Flow: 120.07; Additional Flow: 0; Velocity: 85.3563; Friction: 1.50074; Pressure Drop: 4.6525; Velocity Pressure: 124.053; Reynolds number: 675011
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.7 m; Start Offset: 3.7 m; End Offset: 3.7 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 500/300; Width: 1.64042; Height: 0.984252; Length: 0.944922 m
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:568185
In: Level 1
Type - ElementType: Oval Duct:Gored Elbows / Tees:568185
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.2 m; Start Offset: 3.2 m; End Offset: 3.2 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.05 m; Top Elevation: 3.35 m; Equivalent Diameter: 1.32429; Size Lock: no; Loss Coefficient: 0.0221707; Hydraulic Diameter: 1.27752; Section: 198; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.710439 m2
PSet_Revit_Mechanical - Airflow - Flow: 60.0349; Additional Flow: 0; Velocity: 42.6781; Friction: 0.396024; Pressure Drop: 0.687585; Velocity Pressure: 31.0132; Reynolds number: 337506
PSet_Revit_Dimensions - Size: 500/300; Width: 1.64042; Height: 0.984252; Length: 0.5292 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 921
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:569059
In: Level 2
Type - ElementType: Oval Duct:Gored Elbows / Tees:569059
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Equivalent Diameter: 2.5326; Size Lock: no; Loss Coefficient: 0.123818; Hydraulic Diameter: 2.11828; Section: 60; Insulation Thickness: 0; Lining Thickness: 0; Area: 18.2995 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 360.21; Additional Flow: 0; Velocity: 63.6616; Friction: 0.463465; Pressure Drop: 8.54423; Velocity Pressure: 69.0066; Reynolds number: 834776
PSet_Revit_Identity Data - Mark: 1197
PSet_Revit_Dimensions - Size: 1400/400; Width: 4.59318; Height: 1.31234; Length: 5.61915 m
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:569060
In: Level 2
Type - ElementType: Oval Duct:Gored Elbows / Tees:569060
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Equivalent Diameter: 2.5326; Size Lock: no; Loss Coefficient: 0.305366; Hydraulic Diameter: 2.11828; Section: 60; Insulation Thickness: 0; Lining Thickness: 0; Area: 45.1314 m2
PSet_Revit_Identity Data - Mark: 1198
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 1400/400; Width: 4.59318; Height: 1.31234; Length: 13.8583 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 360.21; Additional Flow: 0; Velocity: 63.6616; Friction: 0.463465; Pressure Drop: 21.0723; Velocity Pressure: 69.0066; Reynolds number: 834776
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:569062
In: Level 2
Type - ElementType: Oval Duct:Gored Elbows / Tees:569062
PSet_Revit_Mechanical - Airflow - Flow: 195.114; Additional Flow: 0; Velocity: 42.5844; Friction: 0.226185; Pressure Drop: 1.34601; Velocity Pressure: 30.8772; Reynolds number: 534185
PSet_Revit_Dimensions - Size: 1150/400; Width: 3.77297; Height: 1.31234; Length: 1.81384 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1199
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Equivalent Diameter: 2.31413; Size Lock: no; Loss Coefficient: 0.0435923; Hydraulic Diameter: 2.02643; Section: 58; Insulation Thickness: 0; Lining Thickness: 0; Area: 5.0001 m2
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:569064
In: Level 2
Type - ElementType: Oval Duct:Gored Elbows / Tees:569064
PSet_Revit_Dimensions - Size: 1000/400; Width: 3.28084; Height: 1.31234; Length: 0.901851 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Equivalent Diameter: 2.166; Size Lock: no; Loss Coefficient: 0.0226855; Hydraulic Diameter: 1.95338; Section: 56; Insulation Thickness: 0; Lining Thickness: 0; Area: 2.21552 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1200
PSet_Revit_Mechanical - Airflow - Flow: 165.096; Additional Flow: 0; Velocity: 41.9454; Friction: 0.229686; Pressure Drop: 0.679601; Velocity Pressure: 29.9575; Reynolds number: 507201
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:569066
In: Level 2
Type - ElementType: Oval Duct:Gored Elbows / Tees:569066
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Equivalent Diameter: 2.05794; Size Lock: no; Loss Coefficient: 0.093527; Hydraulic Diameter: 1.89388; Section: 54; Insulation Thickness: 0; Lining Thickness: 0; Area: 8.09955 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 900/400; Width: 2.95276; Height: 1.31234; Length: 3.58921 m
PSet_Revit_Mechanical - Airflow - Flow: 150.087; Additional Flow: 0; Velocity: 42.8159; Friction: 0.247912; Pressure Drop: 2.91932; Velocity Pressure: 31.2137; Reynolds number: 501957
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1201
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:569071
In: Level 2
Type - ElementType: Oval Duct:Gored Elbows / Tees:569071
PSet_Revit_Mechanical - Airflow - Flow: 120.07; Additional Flow: 0; Velocity: 45.407; Friction: 0.307857; Pressure Drop: 3.15139; Velocity Pressure: 35.1061; Reynolds number: 488080
PSet_Revit_Dimensions - Size: 700/400; Width: 2.29659; Height: 1.31234; Length: 3.12009 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1206
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Equivalent Diameter: 1.81175; Size Lock: no; Loss Coefficient: 0.0897677; Hydraulic Diameter: 1.73644; Section: 52; Insulation Thickness: 0; Lining Thickness: 0; Area: 5.79288 m2
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
