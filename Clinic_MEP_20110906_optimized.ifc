Properties of the parts of a building model (IFC2X3), part 279 of 295

# IfcFlowSegment: Round Duct:Taps / Short Radius:569311
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.35 m; Start Offset: 3.35 m; End Offset: 3.35 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 6.06386; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Identity Data - Mark: 1335
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.275 m; Top Elevation: 3.425 m; Size Lock: no; Loss Coefficient: 0.187091; Hydraulic Diameter: 0.492126; Section: 75; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.784287 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 1.66431 m
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569316
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569316
PSet_Revit_Identity Data - Mark: 1337
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 1.05068 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 0.964927; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5095 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.0940919; Hydraulic Diameter: 0.656168; Section: 84; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.660164 m2
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569318
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569318
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.02231 m; Top Elevation: 3.4095 m; Size Lock: no; Loss Coefficient: 0.034674; Hydraulic Diameter: 0.656168; Section: 84; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.243278 m2
PSet_Revit_Identity Data - Mark: 1338
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.387189 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 0.355587; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.02231 m; Start Offset: 3.02231 m; End Offset: 3.4095 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569321
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569321
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 2.67854 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 9.75918; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Identity Data - Mark: 1339
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5345 m; Top Elevation: 3.6845 m; Size Lock: no; Loss Coefficient: 0.301104; Hydraulic Diameter: 0.492126; Section: 88; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.26223 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569323
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569323
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 1.17251 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.275 m; Top Elevation: 3.425 m; Size Lock: no; Loss Coefficient: 0.131806; Hydraulic Diameter: 0.492126; Section: 88; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.552534 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.35 m; Start Offset: 3.35 m; End Offset: 3.35 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1340
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 4.27201; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569324
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569324
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.56557 m; Start Offset: 3.56557 m; End Offset: 3.39393 m; Slope: 1
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 0.884359; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Identity Data - Mark: 1341
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.3409 m; Top Elevation: 3.6186 m; Size Lock: no; Loss Coefficient: 0.0272855; Hydraulic Diameter: 0.492126; Section: 88; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.114381 m2
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.242724 m
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569327
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569327
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1342
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 2.15923 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.35 m; Start Offset: 3.35 m; End Offset: 3.35 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.275 m; Top Elevation: 3.425 m; Size Lock: no; Loss Coefficient: 0.242727; Hydraulic Diameter: 0.492126; Section: 88; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.01751 m2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 7.8671; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569329
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569329
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5095 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.0813828; Hydraulic Diameter: 0.656168; Section: 99; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.570995 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 0.834593; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Identity Data - Mark: 1346
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.908767 m
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569331
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569331
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5095 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.0153068; Hydraulic Diameter: 0.656168; Section: 101; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.107395 m2
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.170924 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 0.156973; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Identity Data - Mark: 1347
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569337
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569337
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 0.125934; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.137126 m
PSet_Revit_Identity Data - Mark: 1351
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5095 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.0122801; Hydraulic Diameter: 0.656168; Section: 125; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.0861589 m2
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569339
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569339
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.180924 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5095 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.0162023; Hydraulic Diameter: 0.656168; Section: 123; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.113678 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1353
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 0.166157; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569344
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569344
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1364
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 1.95971; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5345 m; Top Elevation: 3.6845 m; Size Lock: no; Loss Coefficient: 0.0604636; Hydraulic Diameter: 0.492126; Section: 90; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.253464 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.537868 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569346
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569346
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 1.98661; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.275 m; Top Elevation: 3.425 m; Size Lock: no; Loss Coefficient: 0.0612937; Hydraulic Diameter: 0.492126; Section: 90; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.256944 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.35 m; Start Offset: 3.35 m; End Offset: 3.35 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1365
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.545253 m
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569347
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569347
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.3409 m; Top Elevation: 3.6186 m; Size Lock: no; Loss Coefficient: 0.0272855; Hydraulic Diameter: 0.492126; Section: 90; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.114381 m2
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.242724 m
PSet_Revit_Identity Data - Mark: 1366
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 0.884359; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.56557 m; Start Offset: 3.56557 m; End Offset: 3.39393 m; Slope: 1
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569350
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569350
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.35 m; Start Offset: 3.35 m; End Offset: 3.35 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 5.10717; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Identity Data - Mark: 1367
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.275 m; Top Elevation: 3.425 m; Size Lock: no; Loss Coefficient: 0.157573; Hydraulic Diameter: 0.492126; Section: 90; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.660551 m2
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 1.40173 m
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569352
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569352
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.251472 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 0.230947; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5095 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.0225201; Hydraulic Diameter: 0.656168; Section: 97; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.158005 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1369
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569353
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569353
PSet_Revit_Identity Data - Mark: 1371
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5095 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.277064; Hydraulic Diameter: 0.656168; Section: 95; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.94393 m2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 2.84134; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 3.09386 m
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569362
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569362
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 0.39425; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.29048 m; Start Offset: 3.29048 m; End Offset: 3.29048 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1378
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.432755 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.16548 m; Top Elevation: 3.41548 m; Size Lock: no; Loss Coefficient: 0.0286964; Hydraulic Diameter: 0.82021; Section: 113; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.339885 m2
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569363
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569363
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.52678 m; Start Offset: 3.52678 m; End Offset: 3.3637 m; Slope: 1
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.27531 m; Top Elevation: 3.61517 m; Size Lock: no; Loss Coefficient: 0.0152932; Hydraulic Diameter: 0.82021; Section: 113; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.181135 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.230628 m
PSet_Revit_Identity Data - Mark: 1379
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 0.210108; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569373
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569373
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.24048 m; Start Offset: 3.24048 m; End Offset: 3.24048 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 1.604; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.14048 m; Top Elevation: 3.34048 m; Size Lock: no; Loss Coefficient: 0.0478212; Hydraulic Diameter: 0.656168; Section: 371; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.379615 m2
PSet_Revit_Identity Data - Mark: 1383
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.604176 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569374
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569374
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.22834 m; Top Elevation: 3.61213 m; Size Lock: no; Loss Coefficient: 0.0271298; Hydraulic Diameter: 0.656168; Section: 371; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.215362 m2
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.34276 m
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 0.909978; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Identity Data - Mark: 1384
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.54142 m; Start Offset: 3.54142 m; End Offset: 3.29905 m; Slope: 1
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569385
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569385
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.708397 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.60002 m; Size Lock: no; Loss Coefficient: 0.0560704; Hydraulic Diameter: 0.656168; Section: 395; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.445099 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.5 m; Start Offset: 3.5 m; End Offset: 3.50003 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1391
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 1.88069; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569386
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569386
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 2.09081; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Identity Data - Mark: 1392
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.5405 m; Start Offset: 3.5405 m; End Offset: 3.54053 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4405 m; Top Elevation: 3.64052 m; Size Lock: no; Loss Coefficient: 0.0623347; Hydraulic Diameter: 0.656168; Section: 392; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.494827 m2
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.787541 m
