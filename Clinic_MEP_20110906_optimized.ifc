Properties of the parts of a building model (IFC2X3), part 20 of 295

# IfcFlowFitting: Elbow - Generic (2063)
Name (M_Elbow - Generic:Elbow - Generic:Elbow - Generic:...) | In | Level | Host | Offset (m) | Mark | Tick Size | Nominal Radius | Nominal Diameter | Insulation Radius = Fitting Outside Radius | Fitting Outside Diameter | Center to End | Angle (deg) | Size | Center Radius | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | System Type | System Name
679869 | Level 1 | Level 1 | Level : Level 1 | 0.5 | 5081 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
997342 | Level 2 | Level 2 | Level : Level 2 | 3.1 | 9967 | 0.0375 | 0.082021 | 0.164042 | 0.046875 | 0.09375 | 0.0677083 | 90 | 50 mmø-50 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
686552 | Level 1 | Level 1 | Level : Level 1 | 0.5 | 5811 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
702609 | Level 1 | Level 1 | Level : Level 1 | 0.371263 | 7652 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
705037 | TOF Footing | Level 1 | Level : Level 1 | -0.25 | 7941 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
657729 | Level 1 | Level 1 | Level : Level 1 | 3.17 | 3635 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
711090 | 1C07 | Level 1 | Level : Level 1 | 0.2 | 8698 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
701794 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7544 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
662690 | Level 2 | Level 2 | Level : Level 2 | 0.5 | 4241 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
701122 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 7476 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
712189 | 1B05 | Level 2 | Level : Level 2 | -1.4 | 8831 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
644958 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 2882 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1068775 | 1D25 | Level 2 | Level : Level 2 | -1.67 | 13643 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Supply | Hydronic Supply 1
648433 | Level 1 | Level 1 | Level : Level 1 | 0 | 3275 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1063308 | 2D05 | Level 2 | Level : Level 2 | 2.985 | 13521 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
640771 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2411 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
683404 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 5413 | 0.0408956 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0631477 | 60 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
629675 | 1D17 | Level 1 | Level : Level 1 | 0 | 863 | 0.0375 | 0.131234 | 0.262467 | 0.046875 | 0.09375 | 0.0677083 | 90 | 80 mmø-80 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
640604 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2394 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
682791 | 1E12 | Level 1 | Level : Level 1 | 0.371263 | 5396 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
698522 | 1DC3 | Level 2 | Level : Level 2 | -1.5 | 7180 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1027122 | 1B04 | Level 1 | Level : Level 1 | 2.985 | 11307 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
682219 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5333 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
685555 | Level 1 | Level 1 | Level : Level 1 | 0.806263 | 5690 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1077364 | Level 1 | Level 1 | Level : Level 1 | 0.806263 | 13946 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
705552 | TOF Footing | Level 1 | Level : Level 1 | -0.25 | 8018 | 0.00862945 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.0194163 | 45 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
997585 | 1CC1 | Level 2 | Level : Level 2 | -1.5 | 9984 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
655611 | 1B07 | Level 2 | Level : Level 2 | -0.2 | 3472 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
1004917 | 1E24 | Level 1 | Level : Level 1 | 2.985 | 10335 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
680343 | Level 1 | Level 1 | Level : Level 1 | 0.371263 | 5138 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
697752 | Level 2 | Level 2 | Level : Level 2 | 0.5 | 7090 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
717390 | 1CC1 | Level 2 | Level : Level 2 | -1.4 | 9342 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
722093 | 1D25 | Level 1 | Level : Level 1 | 4.126 | 9614 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Undefined
680053 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5092 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1114231 | 2A10 | Level 2 | Level : Level 2 | 2.985 | 15094 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1027284 | 1B17 | Level 1 | Level : Level 1 | 2.985 | 11355 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
656376 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 3525 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1049907 | 2D14 | Level 2 | Level : Level 2 | 2.985 | 12467 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1080617 | 1B10 | Level 1 | Level : Level 1 | 0.3 | 14208 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
709142 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8477 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
680561 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5157 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1027140 | 1B04 | Level 1 | Level : Level 1 | 2.985 | 11311 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
681743 | Level 1 | Level 1 | Level : Level 1 | 0.806263 | 5276 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
693373 | Level 2 | Level 2 | Level : Level 2 | 0.3 | 6614 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
660862 | 1C13 | Level 1 | Level : Level 1 | 3 | 3985 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
660593 | Level 1 | Level 2 | Level : Level 2 | -1.6882 | 3928 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
656453 | 1D32 | Level 1 | Level : Level 1 | 0.1 | 3538 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
685861 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5734 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
696321 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 6904 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
700499 | TOF Footing | Level 1 | Level : Level 1 | -0.35 | 7410 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1077349 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 13940 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
693154 | Level 1 | Level 1 | Level : Level 1 | 3.07 | 6603 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
705605 | TOF Footing | Level 1 | Level : Level 1 | -0.25 | 8022 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
697956 | 1D08 | Level 2 | Level : Level 2 | -1.5 | 7108 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
709075 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8466 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
684895 | Level 1 | Level 1 | Level : Level 1 | 0.806263 | 5617 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1073739 | 1D25 | Level 1 | Level : Level 1 | 4.126 | 13783 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Undefined
687868 | 1D06 | Level 1 | Level : Level 1 | 0.806263 | 5972 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
717037 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 9300 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1070461 | 1DC1 | Level 2 | Level : Level 2 | 0.0381 | 13733 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Return | Hydronic Return 1
657209 | Level 1 | Level 1 | Level : Level 1 | 3.1 | 3614 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
664227 | Level 1 | Level 2 | Level : Level 2 | -1.6882 | 4375 | 0.0431472 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.0625635 | 45 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1073759 | 1C06 | Level 2 | Level : Level 2 | -0.444 | 13787 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Undefined
682237 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5334 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
706419 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 8099 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
647887 | Level 1 | Level 1 | Level : Level 1 | 0 | 3239 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
634094 | 1B03 | Level 1 | Level : Level 1 | 2.9 | 1503 | 0.0212396 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.0362039 | 49.7269 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
718929 | 1A16 | Level 2 | Level : Level 2 | -1.4 | 9460 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
703630 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7794 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1081076 | TOF Footing | Level 1 | Level : Level 1 | -0.35 | 14250 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
722091 | 1D25 | Level 1 | Level : Level 1 | 0.3 | 9612 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Undefined
708612 | 1D04 | Level 1 | Level : Level 1 | 0.5 | 8407 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1150880 | Level 2 | Level 2 | Level : Level 2 | 4.236 | 15701 | 0.0375 | 0.164042 | 0.328084 | 0.046875 | 0.09375 | 0.0677083 | 45 | 100 mmø-100 mmø | 0.0677083 |  |  |  |  |  |  | Sanitary | Storm
1051307 | 2D04-A | Level 2 | Level : Level 2 | 2.98518 | 12847 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
684041 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5502 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
659107 | 1D13 | Level 2 | Level : Level 2 | -1.6882 | 3771 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
718444 | 2C24 | Level 2 | Level : Level 2 | 0.2 | 9410 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1077595 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 13971 | 0.00349771 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.00786985 | 19.061 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
685068 | Level 1 | Level 1 | Level : Level 1 | 0.806263 | 5645 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1051775 | 2C03 | Level 2 | Level : Level 2 | 2.985 | 12967 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
714559 | 1D08 | Level 2 | Level : Level 2 | -1.4 | 9061 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
703502 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 7777 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
638976 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 2146 | 0.02927 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0451963 | 44.9031 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
696368 | Level 2 | Level 2 | Level : Level 2 | 0.5 | 6916 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
707817 | 1A12 | Level 1 | Level : Level 1 | 0.2 | 8278 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1068763 | 1D25 | Level 2 | Level : Level 2 | -1.67 | 13641 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Supply | Hydronic Supply 1
704913 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7915 | 0.0189848 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.0323604 | 45 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
707808 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8275 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
686443 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5792 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
637399 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 2007 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1078062 | 1D08 | Level 1 | Level : Level 1 | 0.2 | 14006 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1077172 | 1D07 | Level 1 | Level : Level 1 | 0.635088 | 13919 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
699950 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7374 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
637684 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 2063 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
661834 | 1C07 | Level 2 | Level : Level 2 | -1.6882 | 4112 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
717779 | 1CC1 | Level 2 | Level : Level 2 | -1.4 | 9380 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1001048 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 10119 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
656089 | Level 1 | Level 1 | Level : Level 1 | 2.8818 | 3509 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
682286 | Level 1 | Level 1 | Level : Level 1 | 0.688244 | 5341 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1074780 | 1D21 | Level 2 | Level : Level 2 | -4.27 | 13841 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Storm
663667 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 4325 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
692950 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 6565 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1067500 | TOF Footing | Level 1 | Level : Level 1 | -0.6 | 13547 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Return | Hydronic Return 1
701806 | 1E11 | Level 1 | Level : Level 1 | 0.2 | 7548 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
700898 | 1E09 | Level 1 | Level : Level 1 | 0.3 | 7453 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
643376 | Level 1 | Level 1 | Level : Level 1 | 2.9 | 2720 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
1078212 | 1D31 | Level 1 | Level : Level 1 | 0.5 | 14018 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1048183 | 2C17 | Level 2 | Level : Level 2 | 2.985 | 12051 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
708157 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8345 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
705295 | TOF Footing | Level 1 | Level : Level 1 | -0.25 | 7984 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
715002 | Level 2 | Level 2 | Level : Level 2 | 0.9144 | 9100 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
680268 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5121 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
718930 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 9461 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
636771 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1937 | 0.0431472 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.0625635 | 45 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
661358 | Level 2 | Level 2 | Level : Level 2 | 2.9 | 4047 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1082860 | 1A09 | Level 2 | Level : Level 2 | -1.5 | 14391 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
706085 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8062 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
662848 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 4250 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1076382 | 1D13 | Level 1 | Level : Level 1 | 0.2 | 13877 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
654243 | Level 2 | Level 1 | Level : Level 1 | 5.57 | 3341 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
708064 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8324 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
689187 | Level 1 | Level 1 | Level : Level 1 | 0.5 | 6153 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
688756 | Level 1 | Level 1 | Level : Level 1 | 0.806263 | 6097 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
714956 | Level 2 | Level 2 | Level : Level 2 | 0.9144 | 9098 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
658101 | 1DC4 | Level 2 | Level : Level 2 | -1.6882 | 3660 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
669577 | 1D27 | Level 2 | Level : Level 2 | -1.6882 | 4800 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
642010 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 2533 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
640545 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2381 | 0.0426843 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.0618922 | 44.5646 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
718427 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 9405 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1049302 | 2D05 | Level 2 | Level : Level 2 | 2.985 | 12315 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
633848 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1476 | 0.0293401 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0453046 | 45 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
716387 | 1C15 | Level 2 | Level : Level 2 | -1.35 | 9239 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
643110 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2692 | 0.0293401 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0453046 | 45 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
1028583 | 1AC3 | Level 1 | Level : Level 1 | 2.985 | 11664 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
689637 | Level 1 | Level 1 | Level : Level 1 | 0.371263 | 6199 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
683929 | 1D40 | Level 1 | Level : Level 1 | 0.371263 | 5489 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1078516 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 14048 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
717898 | 1D04 | Level 2 | Level : Level 2 | -1.4 | 9398 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
642631 | Level 1 | Level 1 | Level : Level 1 | 2.9 | 2618 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
697362 | 1A03 | Level 2 | Level : Level 2 | -1.5 | 7035 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
689293 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 6167 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
707807 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8274 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1082862 | 1A09 | Level 2 | Level : Level 2 | -1.5 | 14393 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
711092 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8700 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
708417 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8377 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
692351 | Level 1 | Level 2 | Level : Level 2 | -0.411 | 6503 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
712202 | Level 2 | Level 2 | Level : Level 2 | 0.3 | 8838 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
718754 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 9442 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
719365 | 1A05 | Level 2 | Level : Level 2 | -1.45 | 9503 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
647479 | Level 1 | Level 1 | Level : Level 1 | 0.232932 | 3192 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
696142 | Level 2 | Level 2 | Level : Level 2 | 0.5 | 6875 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1051763 | 2C23 | Level 2 | Level : Level 2 | 2.985 | 12963 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
684677 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5580 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
706086 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 8063 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1070243 | 1D26 | Level 2 | Level : Level 2 | 0.0381 | 13700 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Return | Hydronic Return 1
1082736 | Level 1 | Level 2 | Level : Level 2 | -1.5 | 14383 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1001358 | 1B19 | Level 1 | Level : Level 1 | 2.985 | 10144 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
705622 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8030 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1049543 | 2D10 | Level 2 | Level : Level 2 | 2.985 | 12383 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
648435 | Level 1 | Level 1 | Level : Level 1 | 2.8 | 3277 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
998845 | 1D21 | Level 1 | Level : Level 1 | 3 | 10027 | 0.0375 | 0.0656168 | 0.131234 | 0.046875 | 0.09375 | 0.0677083 | 36.3694 | 40 mmø-40 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
680652 | Level 1 | Level 1 | Level : Level 1 | 0.371263 | 5169 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1150951 | 2A06 | Level 2 | Level : Level 2 | 4.236 | 15713 | 0.0375 | 0.246063 | 0.492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 150 mmø-150 mmø | 0.0677083 |  |  |  |  |  |  | Sanitary | Storm
637906 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 2090 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
710319 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8604 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
687646 | Level 1 | Level 1 | Level : Level 1 | 0.6 | 5940 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1068770 | 1D25 | Level 2 | Level : Level 2 | -1.67 | 13642 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Supply | Hydronic Supply 1
1110132 | Level 1 | Level 2 | Level : Level 2 | -1.6882 | 15027 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
692954 | Level 2 | Level 2 | Level : Level 2 | 0.688244 | 6569 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
706240 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8076 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1049224 | 2DC2 | Level 2 | Level : Level 2 | 2.985 | 12283 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
660848 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 3982 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
641092 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2412 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
658030 | Level 1 | Level 2 | Level : Level 2 | -1.6882 | 3654 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
634442 | Level 1 | Level 1 | Level : Level 1 | 2.9 | 1575 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
680321 | Level 1 | Level 1 | Level : Level 1 | 0.688244 | 5128 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1080052 | 1E04 | Level 1 | Level : Level 1 | 0.635088 | 14159 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1082525 | 2C02 | Level 2 | Level : Level 2 | 0.806263 | 14359 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
635158 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 1721 | 0.022327 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.036496 | 44.802 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
661742 | 2C04 | Level 2 | Level : Level 2 | 2.9 | 4100 | 0.0224366 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0366752 | 45 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1076681 | 1D11 | Level 1 | Level : Level 1 | 0.5 | 13888 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1080340 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 14177 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
656929 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 3578 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
678269 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 4935 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1029035 | 2D16 | Level 2 | Level : Level 2 | 2.985 | 11723 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
637204 | TOF Footing | Level 1 | Level : Level 1 | -0.479363 | 1986 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
660632 | Level 1 | Level 2 | Level : Level 2 | -1.6882 | 3932 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1027192 | 1B04 | Level 1 | Level : Level 1 | 2.985 | 11327 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
680672 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5175 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
704432 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7891 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1049050 | 2DC2 | Level 2 | Level : Level 2 | 2.985 | 12219 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1086788 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 14742 | 0.0288009 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0470784 | 56 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
708063 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8323 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1118042 | 2C10 | Level 2 | Level : Level 2 | 0.860313 | 15119 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
716841 | 1D13 | Level 2 | Level : Level 2 | -1.4 | 9275 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
633293 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1410 | 0.0430794 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.0624651 | 44.9363 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1079968 | 1E04 | Level 1 | Level : Level 1 | 0.2 | 14142 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1082879 | 2A08 | Level 2 | Level : Level 2 | 0.2 | 14397 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
660846 | Level 1 | Level 1 | Level : Level 1 | 3 | 3980 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
704224 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7872 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
699418 | 1D16 | Level 2 | Level : Level 2 | -1.6882 | 7292 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
716335 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 9229 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
699011 | Level 1 | Level 2 | Level : Level 2 | -1.5 | 7271 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
