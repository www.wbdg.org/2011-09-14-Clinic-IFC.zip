Properties of the parts of a building model (IFC2X3), part 284 of 295

# IfcFlowSegment: Round Duct:Taps / Short Radius:569635
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569647
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569647
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5095 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.0894888; Hydraulic Diameter: 0.656168; Section: 247; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.627868 m2
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.999283 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1571
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 0.917722; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569652
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569652
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.581603 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5345 m; Top Elevation: 3.7345 m; Size Lock: no; Loss Coefficient: 0.0520843; Hydraulic Diameter: 0.656168; Section: 267; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.365432 m2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 0.534132; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Identity Data - Mark: 1573
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6345 m; Start Offset: 3.6345 m; End Offset: 3.6345 m; Slope: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569655
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569655
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.76466 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5595 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.085958; Hydraulic Diameter: 0.492126; Section: 263; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.360337 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6345 m; Start Offset: 3.6345 m; End Offset: 3.6345 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1577
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 2.78601; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569657
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569657
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.415716 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.275 m; Top Elevation: 3.425 m; Size Lock: no; Loss Coefficient: 0.046732; Hydraulic Diameter: 0.492126; Section: 263; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.195901 m2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 1.51465; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.35 m; Start Offset: 3.35 m; End Offset: 3.35 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1578
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569658
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569658
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5595 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.0141459; Hydraulic Diameter: 0.492126; Section: 263; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.0592997 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 0.458487; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6345 m; Start Offset: 3.6345 m; End Offset: 3.6345 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1579
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.125838 m
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569659
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569659
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.3409 m; Top Elevation: 3.6436 m; Size Lock: no; Loss Coefficient: 0.0312599; Hydraulic Diameter: 0.492126; Section: 263; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.131042 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.27808 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 1.01317; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.59057 m; Start Offset: 3.59057 m; End Offset: 3.39393 m; Slope: 1
PSet_Revit_Identity Data - Mark: 1580
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569667
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569667
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4845 m; Top Elevation: 3.7345 m; Size Lock: no; Loss Coefficient: 0.0373102; Hydraulic Diameter: 0.82021; Section: 256; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.389733 m2
PSet_Revit_Identity Data - Mark: 1583
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.496223 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.0962648; Pressure Drop: 0.156722; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569669
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569669
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4845 m; Top Elevation: 3.7345 m; Size Lock: no; Loss Coefficient: 0.0256444; Hydraulic Diameter: 0.82021; Section: 261; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.267874 m2
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.341068 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1586
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.0962648; Pressure Drop: 0.107719; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569681
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569681
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5095 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.154273; Hydraulic Diameter: 0.656168; Section: 184; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.0824 m2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 1.58209; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 1.7227 m
PSet_Revit_Identity Data - Mark: 1592
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569683
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569683
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.206907 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 0.19002; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Identity Data - Mark: 1595
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5095 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.0185292; Hydraulic Diameter: 0.656168; Section: 265; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.130004 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569685
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569685
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.35 m; Start Offset: 3.35 m; End Offset: 3.35 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1596
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 2.74836 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.25 m; Top Elevation: 3.45 m; Size Lock: no; Loss Coefficient: 0.246124; Hydraulic Diameter: 0.656168; Section: 265; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.72684 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 2.52404; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569686
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569686
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.33787 m; Top Elevation: 3.62163 m; Size Lock: no; Loss Coefficient: 0.0180273; Hydraulic Diameter: 0.656168; Section: 265; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.126482 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.55092 m; Start Offset: 3.55092 m; End Offset: 3.40858 m; Slope: 1
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 0.184873; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1597
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.201303 m
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569699
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569699
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5095 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.0160382; Hydraulic Diameter: 0.656168; Section: 167; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.112527 m2
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.179092 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1606
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 0.164474; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569701
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569701
PSet_Revit_Identity Data - Mark: 1610
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5095 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.102283; Hydraulic Diameter: 0.656168; Section: 178; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.717634 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 1.14215 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 1.04893; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569704
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569704
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 10.9074; Friction: 0.0404908; Pressure Drop: 0.195825; Velocity Pressure: 2.02571; Reynolds number: 66456.3
PSet_Revit_Identity Data - Mark: 1613
PSet_Revit_Dimensions - Size: 300ø; Diameter: 0.984252; Length: 1.4741 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4595 m; Top Elevation: 3.7595 m; Size Lock: no; Loss Coefficient: 0.0966698; Hydraulic Diameter: 0.984252; Section: 180; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.3893 m2
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569717
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569717
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5095 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.0214927; Hydraulic Diameter: 0.656168; Section: 409; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.150796 m2
PSet_Revit_Identity Data - Mark: 1622
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 0.220411; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.24 m
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569719
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569719
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5095 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.0319845; Hydraulic Diameter: 0.656168; Section: 409; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.224409 m2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 0.328006; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Identity Data - Mark: 1623
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.357157 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569721
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569721
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.2 m; Start Offset: 3.2 m; End Offset: 3.2 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 1.36624; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 1.48766 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.1 m; Top Elevation: 3.3 m; Size Lock: no; Loss Coefficient: 0.133224; Hydraulic Diameter: 0.656168; Section: 409; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.934723 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1624
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569722
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569722
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.413435 m
PSet_Revit_Identity Data - Mark: 1625
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.18787 m; Top Elevation: 3.62163 m; Size Lock: no; Loss Coefficient: 0.0370244; Hydraulic Diameter: 0.656168; Section: 409; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.259769 m2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 0.379691; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.55092 m; Start Offset: 3.55092 m; End Offset: 3.25858 m; Slope: 1
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569725
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569725
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.1 m; Top Elevation: 3.3 m; Size Lock: no; Loss Coefficient: 0.184121; Hydraulic Diameter: 0.656168; Section: 409; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.29182 m2
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 2.056 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.2 m; Start Offset: 3.2 m; End Offset: 3.2 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1626
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 1.88819; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569730
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569730
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1628
PSet_Revit_Dimensions - Size: 300ø; Diameter: 0.984252; Length: 0.555031 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 10.9074; Friction: 0.0404908; Pressure Drop: 0.0737325; Velocity Pressure: 2.02571; Reynolds number: 66456.3
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4595 m; Top Elevation: 3.7595 m; Size Lock: no; Loss Coefficient: 0.0363983; Hydraulic Diameter: 0.984252; Section: 158; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.523104 m2
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569736
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569736
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1631
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5345 m; Top Elevation: 3.6845 m; Size Lock: no; Loss Coefficient: 0.0708461; Hydraulic Diameter: 0.492126; Section: 302; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.296988 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.630228 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 2.29622; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
