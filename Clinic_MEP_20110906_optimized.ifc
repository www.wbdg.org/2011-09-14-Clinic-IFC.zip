Properties of the parts of a building model (IFC2X3), part 236 of 295

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569734
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569757
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569757
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 23.2393; Friction: 0.203619; Pressure Drop: 0.66733; Velocity Pressure: 9.19563; Reynolds number: 113273
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1645
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.60952 m; Start Offset: 3.60952 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Dimensions - Size: 200x300; Width: 0.656168; Height: 0.984252; Length: 0.998934 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4595 m; Top Elevation: 3.75952 m; Equivalent Diameter: 0.874038; Size Lock: no; Loss Coefficient: 0.0725704; Hydraulic Diameter: 0.787402; Section: 280; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.998934 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569761
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569761
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 15.4929; Friction: 0.07483; Pressure Drop: 0.419596; Velocity Pressure: 4.08695; Reynolds number: 94394.5
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.60952 m; Start Offset: 3.60952 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4595 m; Top Elevation: 3.75952 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.102667; Hydraulic Diameter: 0.984252; Section: 270; Insulation Thickness: 0; Lining Thickness: 0; Area: 2.05093 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1650
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 1.70911 m
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569769
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569769
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0467694; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.60951 m; Start Offset: 3.60951 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1657
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.537295 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4595 m; Top Elevation: 3.75951 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0374288; Hydraulic Diameter: 0.984252; Section: 286; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.644755 m2
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569778
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569778
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.60952 m; Start Offset: 3.60952 m; End Offset: 3.60952 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 15.4929; Friction: 0.07483; Pressure Drop: 0.0496778; Velocity Pressure: 4.08695; Reynolds number: 94394.5
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.45952 m; Top Elevation: 3.75952 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0121552; Hydraulic Diameter: 0.984252; Section: 290; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.242819 m2
PSet_Revit_Identity Data - Mark: 1667
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.202349 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569783
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569783
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 17.1333; Friction: 0.148143; Pressure Drop: 0.374709; Velocity Pressure: 4.99824; Reynolds number: 69592.8
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.60952 m; Start Offset: 3.60952 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1668
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 150x300; Width: 0.492126; Height: 0.984252; Length: 0.770954 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4595 m; Top Elevation: 3.75952 m; Equivalent Diameter: 0.749692; Size Lock: no; Loss Coefficient: 0.0749682; Hydraulic Diameter: 0.656168; Section: 308; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.693858 m2
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569789
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569789
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5345 m; Top Elevation: 3.6845 m; Equivalent Diameter: 0.749692; Size Lock: no; Loss Coefficient: 0.000416524; Hydraulic Diameter: 0.656168; Section: 311; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.00385508 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 300x150; Width: 0.984252; Height: 0.492126; Length: 0.00428342 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1672
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 17.1333; Friction: 0.148143; Pressure Drop: 0.00208188; Velocity Pressure: 4.99824; Reynolds number: 69592.8
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569796
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569796
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 23.2393; Friction: 0.203619; Pressure Drop: 1.08244; Velocity Pressure: 9.19563; Reynolds number: 113273
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1674
PSet_Revit_Dimensions - Size: 300x200; Width: 0.984252; Height: 0.656168; Length: 1.62032 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.30948 m; Top Elevation: 3.50948 m; Equivalent Diameter: 0.874038; Size Lock: no; Loss Coefficient: 0.117713; Hydraulic Diameter: 0.787402; Section: 318; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.62032 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.40948 m; Start Offset: 3.40948 m; End Offset: 3.40948 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569814
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569814
PSet_Revit_Identity Data - Mark: 1685
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.25948 m; Top Elevation: 3.55948 m; Equivalent Diameter: 0.749692; Size Lock: no; Loss Coefficient: 0.137023; Hydraulic Diameter: 0.656168; Section: 342; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.2682 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 150x300; Width: 0.492126; Height: 0.984252; Length: 1.40911 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 17.1333; Friction: 0.148143; Pressure Drop: 0.684875; Velocity Pressure: 4.99824; Reynolds number: 69592.8
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.40948 m; Start Offset: 3.40948 m; End Offset: 3.40948 m; Slope: 0
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569816
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569816
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 17.1333; Friction: 0.148143; Pressure Drop: 0.850126; Velocity Pressure: 4.99824; Reynolds number: 69592.8
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.40948 m; Start Offset: 3.40948 m; End Offset: 3.40948 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1686
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.25948 m; Top Elevation: 3.55948 m; Equivalent Diameter: 0.749692; Size Lock: no; Loss Coefficient: 0.170085; Hydraulic Diameter: 0.656168; Section: 340; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.5742 m2
PSet_Revit_Dimensions - Size: 150x300; Width: 0.492126; Height: 0.984252; Length: 1.74911 m
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569818
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569818
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.2845 m; Top Elevation: 3.53452 m; Equivalent Diameter: 0.688942; Size Lock: no; Loss Coefficient: 0.108699; Hydraulic Diameter: 0.615157; Section: 338; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.863431 m2
PSet_Revit_Identity Data - Mark: 1687
PSet_Revit_Dimensions - Size: 150x250; Width: 0.492126; Height: 0.82021; Length: 1.07929 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.40953 m; Start Offset: 3.40953 m; End Offset: 3.4095 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 20.5599; Friction: 0.220945; Pressure Drop: 0.78236; Velocity Pressure: 7.19746; Reynolds number: 78291.9
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569825
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569825
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.40952 m; Start Offset: 3.40952 m; End Offset: 3.4095 m; Slope: 0
PSet_Revit_Dimensions - Size: 200x300; Width: 0.656168; Height: 0.984252; Length: 1.501 m
PSet_Revit_Identity Data - Mark: 1696
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 23.2393; Friction: 0.203619; Pressure Drop: 1.00273; Velocity Pressure: 9.19563; Reynolds number: 113273
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.2595 m; Top Elevation: 3.55952 m; Equivalent Diameter: 0.874038; Size Lock: no; Loss Coefficient: 0.109044; Hydraulic Diameter: 0.787402; Section: 330; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.501 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569840
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569840
PSet_Revit_Identity Data - Mark: 1705
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 150x350; Width: 0.492126; Height: 1.14829; Length: 1.35671 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4345 m; Top Elevation: 3.7845 m; Equivalent Diameter: 0.804054; Size Lock: no; Loss Coefficient: 0.128999; Hydraulic Diameter: 0.688976; Section: 231; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.35671 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 14.6857; Friction: 0.106423; Pressure Drop: 0.473707; Velocity Pressure: 3.67217; Reynolds number: 62633.6
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569847
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569847
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4595 m; Top Elevation: 3.7595 m; Equivalent Diameter: 0.749692; Size Lock: no; Loss Coefficient: 0.0843465; Hydraulic Diameter: 0.656168; Section: 221; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.8902 m2
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 30.9857; Friction: 0.424909; Pressure Drop: 1.37888; Velocity Pressure: 16.3478; Reynolds number: 125859
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1708
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 150x300; Width: 0.492126; Height: 0.984252; Length: 0.989112 m
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569864
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569864
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4845 m; Top Elevation: 3.73452 m; Equivalent Diameter: 0.896625; Size Lock: no; Loss Coefficient: 0.0850356; Hydraulic Diameter: 0.82021; Section: 234; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.21929 m2
PSet_Revit_Dimensions - Size: 250x250; Width: 0.82021; Height: 0.82021; Length: 1.21929 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.60952 m; Start Offset: 3.60952 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1716
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 22.3097; Friction: 0.180149; Pressure Drop: 0.72065; Velocity Pressure: 8.47469; Reynolds number: 113273
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569866
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569866
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 20.5599; Friction: 0.220945; Pressure Drop: 0.785761; Velocity Pressure: 7.19746; Reynolds number: 78291.9
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.60952 m; Start Offset: 3.60952 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4845 m; Top Elevation: 3.73452 m; Equivalent Diameter: 0.688942; Size Lock: no; Loss Coefficient: 0.109172; Hydraulic Diameter: 0.615157; Section: 201; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.867184 m2
PSet_Revit_Identity Data - Mark: 1717
PSet_Revit_Dimensions - Size: 150x250; Width: 0.492126; Height: 0.82021; Length: 1.08398 m
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569868
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569868
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 20.5599; Friction: 0.220945; Pressure Drop: 0.680876; Velocity Pressure: 7.19746; Reynolds number: 78291.9
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.494 m; Top Elevation: 3.74402 m; Equivalent Diameter: 0.688942; Size Lock: no; Loss Coefficient: 0.0945995; Hydraulic Diameter: 0.615157; Section: 199; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.751431 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.61902 m; Start Offset: 3.61902 m; End Offset: 3.619 m; Slope: 0
PSet_Revit_Dimensions - Size: 150x250; Width: 0.492126; Height: 0.82021; Length: 0.939289 m
PSet_Revit_Identity Data - Mark: 1718
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569870
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569870
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 30.9857; Friction: 0.424909; Pressure Drop: 1.25267; Velocity Pressure: 16.3478; Reynolds number: 125859
PSet_Revit_Identity Data - Mark: 1719
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4595 m; Top Elevation: 3.75952 m; Equivalent Diameter: 0.749692; Size Lock: no; Loss Coefficient: 0.0766263; Hydraulic Diameter: 0.656168; Section: 192; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.808721 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.60952 m; Start Offset: 3.60952 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Dimensions - Size: 150x300; Width: 0.492126; Height: 0.984252; Length: 0.898579 m
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569888
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569888
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.9016 m; Start Offset: 2.9016 m; End Offset: 3.43452 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0463885; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.532919 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 2.9016 m; Top Elevation: 3.43452 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0371239; Hydraulic Diameter: 0.984252; Section: 241; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.639503 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1738
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569889
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569889
PSet_Revit_Identity Data - Mark: 1739
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.205852 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.45952 m; Top Elevation: 3.75952 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0143399; Hydraulic Diameter: 0.984252; Section: 241; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.247022 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.60952 m; Start Offset: 3.60952 m; End Offset: 3.60952 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0179186; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569912
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569912
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Default Supply Air (cskender); Bottom Elevation: 3.25947 m; Top Elevation: 3.45947 m; Equivalent Diameter: 0.7173; Size Lock: no; Loss Coefficient: 0.216051; Hydraulic Diameter: 0.656168; Section: 0; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.83057 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.35947 m; Start Offset: 3.35947 m; End Offset: 3.35947 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1750
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 19.2749; Friction: 0.182053; Pressure Drop: 1.36672; Velocity Pressure: 6.32589; Reynolds number: 78291.9
PSet_Revit_Dimensions - Size: 200x200; Width: 0.656168; Height: 0.656168; Length: 2.28821 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:569926
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:569926
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.9 m; Start Offset: 3.9 m; End Offset: 3.9 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1756
PSet_Revit_Dimensions - Size: 600x500; Width: 1.9685; Height: 1.64042; Length: 5.6 m
PSet_Revit_Mechanical - Airflow - Flow: 66.3916; Additional Flow: 0; Velocity: 20.5599; Friction: 0.0606932; Pressure Drop: 1.1151; Velocity Pressure: 7.19746; Reynolds number: 227758
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.65 m; Top Elevation: 4.15 m; Equivalent Diameter: 1.96237; Size Lock: no; Loss Coefficient: 0.154929; Hydraulic Diameter: 1.78955; Section: 89; Insulation Thickness: 0; Lining Thickness: 0; Area: 12.32 m2
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
