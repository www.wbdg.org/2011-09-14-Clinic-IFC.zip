Properties of the parts of a building model (IFC2X3), part 8 of 295

# IfcSpace (526)
Name | In | LongName = Name | Area (m2) = GSA BIM Area (m2) | Perimeter (m) | Unbounded Height (m) | Volume (m3) | Level | Upper Limit | Limit Offset (m) | Base Offset (m) | Category Description | Category Code | CirculationZoneName | FireAlarmZoneName | HistoricPreservationZoneName | LightingZoneName | OccupancyZoneName | VentilationZoneName | Number | OmniClass Table 13 Category | RoomTag
2C01 | Level 2 | DTR SUPPORT | 8.72505 | 11.958 | 4.68 | 37.9803 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C01 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1C05 | Level 1 | VISUAL FIELD | 11.3446 | 14.538 | 4.57 | 46.1775 | Level 1 | Level 2 | 0 | 0 | Physical Examination Room | 13-41 41 14 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C05 | 13-41 41 14: Physical Examination Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D40 | Level 1 | IMMUNIZ'N ROOM | 16.5524 | 19.222 | 4.57 | 70.3775 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D40 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E25 | Level 1 | ADP EQUIP SPACE | 11.3734 | 13.9988 | 4.57 | 48.2632 | Level 1 | Level 2 | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E25 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B04 | Level 1 | LAB | 53.5882 | 36.948 | 4.57 | 233.961 | Level 1 | Level 2 | 0 | 0 | Laboratory | 13-15 11 24 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B04 | 13-15 11 24 11: Laboratory | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D32 | Level 1 | INTERACTION STATION | 12.7483 | 14.814 | 4.57 | 54.2672 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D32 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D13 | Level 1 | INTERACTION STATION | 12.8258 | 14.432 | 4.57 | 54.5951 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D13 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1A01 | Level 1 | PATIENT ADMIN. RECEPT. | 19.7671 | 19.072 | 4.57 | 86.9074 | Level 1 | Level 2 | 0 | 0 | Reception Space | 13-11 11 31 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A01 | 13-11 11 31: Reception Space | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1C10 | Level 1 | OPT. EXAM / OFF. | 18.2545 | 20.8688 | 4.57 | 77.6049 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C10 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E18 | Level 1 | BIOMED MAINT. ADMIN. | 15.5543 | 15.9435 | 4.57 | 65.6404 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E18 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1AS1 | Level 1 | STAIR | 14.0577 | 15.646 | 4.57 | 62.0448 | Level 1 | Level 2 | 0 | 0 | Stairway | 13-85 21 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1AS1 | 13-85 21 11: Stairway | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E15-A | Level 1 | GAS STORAGE | 2.28945 | 7.3006 | 4.57 | 7.57512 | Level 1 | Level 2 | 0 | 0 | Hazardous Material Storage Space | 13-75 41 24 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E15-A | 13-75 41 24: Hazardous Material Storage Space | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1CS3 | Level 1 | STAIR | 13.9094 | 18.996 | 4.57 | 58.2892 | Level 1 | Level 2 | 0 | 0 | Stairway | 13-85 21 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1CS3 | 13-85 21 11: Stairway | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2AC1-B | Level 2 | OPEN TO BELOW | 75.807 | 35.407 | 4.68 | 348.032 | Level 2 | Roof - Main | 0 | 0 | Other Transitional Circulation Spaces | 13-85 31 99 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2AC1-B | 13-85 31 99: Other Transitional Circulation Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2AC1-A | Level 2 | OPEN TO BELOW | 67.5856 | 37.0386 | 4.68 | 308.383 | Level 2 | Roof - Main | 0 | 0 | Other Transitional Circulation Spaces | 13-85 31 99 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2AC1-A | 13-85 31 99: Other Transitional Circulation Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity

# IfcEnergyConversionDevice: 633-703 kW, M_Screw Chiller - Air Cooled - 281-1231 kW:633-703 kW:633-703 kW:1066741
In: Level 1
Type - ElementType: 633-703 kW; PredefinedType: USERDEFINED
PSet_Revit_Type_Electrical - Voltage: 4951.4; Load Classification: Cooling; Number of Poles: 3
PSet_Revit_Type_Other - Radius 1: 0.227 m; Number of Fans: 12; Length 2: 0.2524 m; Length 1: 1.565 m; Half Number of Fans: 6; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.10.24.21.21.21; OmniClass Title: Rotary-Screw Water Chillers
PSet_Revit_Type_Dimensions - Chilled Water Supply Radius: 0.246063; Chilled Water Supply Diameter: 0.492126; Chilled Water Return Radius: 0.244751; Chilled Water Return Diameter: 0.489501; Chiller Length: 7.168 m; C2 Offset 2: 0.287 m; C1 Offset 3: 4.512 m; C1 Offset 2: 0.571 m; C1 Offset 1: 1.782 m
PSet_Revit_Other - TagNumber: ACC-1; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Chilled Water Pressure Drop: 10570.5; Drain Flow: 0; Chilled Water Flow: 0.388461; Cold Capacity: 2857700; System Type: Hydronic Return,Hydronic Supply,Sanitary,Power; System Name: Hydronic Return 1,Hydronic Supply 1,Sanitary 1
PSet_Revit_Identity Data - Mark: ACC-1
PSet_Revit_Electrical - Loads - Apparent Load: 985974; Panel: MS1; Circuit Number: 3
PSet_Revit_Constraints - Level: Level 1; Host: Level : Level 1; Offset: 0 m

# IfcEnergyConversionDevice: 914mmx673mm (2)
In: 1B23
Type - ElementType: 914mmx673mm; PredefinedType: VOLTAGE
PSet_Revit_General - Location: ELEC. ROOM 1B23-M; Mounting: Recessed; Enclosure: Type 1
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Level: Level 1; Host: Level : Level 1; Offset: 0 m
PSet_Revit_Electrical - Loads - Appliance - Dwelling Unit Demand Factor: 1
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Electrical - Circuiting - Mains: 100; Number of Wires: 4; Number of Phases: 3; Electrical Data: 208 V/3-0 VA
PSet_Revit_Type_Dimensions - Switchboard Width: 0.673 m; Switchboard Length: 0.914 m; Switchboard Height: 2.286 m
PSet_Revit_Type_Other - Panel Length: 0.8124 m; Panel Height: 0.508 m; Length 1: 0.914 m; Height 1: 2.286 m; Half Switchboard Length: 0.457 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels
PSet_Revit_Type_Electrical - Primary Voltage: 2238.89; Primary Number of Poles: 3; Load Classification: Other
Name (M_Transformer Switchboard:914mmx673mm:...) | Panel Name = TagNumber | Mark | Total Connected | Total Estimated Demand | Total Demand Factor | Total Connected Current | Total Estimated Demand Current | Apparent Load Phase A | Apparent Load Phase B | Apparent Load Phase C | Current Phase A | Current Phase B | Current Phase C | Appliance - Dwelling Unit Connected = Appliance - Dwelling Unit Estimated Demand | Appliance - Dwelling Unit Connected Current = Appliance - Dwelling Unit Estimated Demand Current | Distribution System
MS1:860947 | MS1 | 12 | 1001926 | 1001926 | 1 | 111.96 | 111.96 | 333975 | 333975 | 333975 | 112.012 | 112.012 | 112.012 | 5834.04 | 0.651925 | 480/277 Wye | PSet_Revit_Electrical - Loads - Cooling Connected: 996092; Cooling Estimated Demand: 996092; Cooling Connected Current: 111.308; Cooling Estimated Demand Current: 111.308; Cooling Demand Factor: 1
MS2:861040 | MS2 | 13 | 2596707 | 1294432 | 0.49849 | 669.621 | 333.799 | 983369 | 826302 | 787036 | 761.317 | 639.717 | 609.317 | 48437.6 | 12.4908 | 120/208 Wye | PSet_Revit_Electrical - Loads - Other Connected: 0; Other Estimated Demand: 0; Other Connected Current: 0; Other Estimated Demand Current: 0; Lighting - Dwelling Unit Connected: 686328; Lighting - Dwelling Unit Estimated Demand: 261205; Lighting - Dwelling Unit Connected Current: 176.986; Lighting - Dwelling Unit Estimated Demand Current: 67.3576; Lighting - Dwelling Unit Demand Factor: 0.380582; Receptacle Connected: 1861941; Receptacle Estimated Demand: 984790; Receptacle Connected Current: 480.144; Receptacle Estimated Demand Current: 253.951; Receptacle Demand Factor: 0.528905

# IfcFlowController: 100 mm, M_Ball Valve - 50-150 mm:100 mm:100 mm:1060496
In: TOF Footing
Type - ElementType: 100 mm
PSet_Revit_Type_Other - Radius: 0.1175 m; Length 2: 0.05725 m; Length 1: 0.1832 m; Half Nut Height: 0.0165 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - K Coefficient: 0.3
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Dimensions - Stem Radius: 0.01 m; Stem Height: 0.055 m; Stem Diameter: 0.02 m; Seal Length: 0.05725 m; Nut Radius: 0.015 m; Nut Height: 0.033 m; Nut Diameter: 0.03 m; Nominal Radius: 0.164042; Nominal Diameter: 0.328084; Handle Width: 0.051 m; Handle Length: 0.178 m; Handle Height: 0.502 m; Body Radius: 0.055 m; Body Length: 0.229 m; Body Height: 0.143 m; Body Diameter: 0.11 m; Adapter Radius: 0.08 m; Adapter Length: 0.0229 m; Adapter Diameter: 0.16 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.65.55.14.17; OmniClass Title: Adjusting/Controlling Valves for Liquid Services
PSet_Revit_Constraints - Level: Level 1; Host: Level : Level 1; Offset: -0.4 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Loss Method: 5
PSet_Revit_Dimensions - Size: 100 mmø-100 mmø
PSet_Revit_Identity Data - Mark: 179
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Use Annotation Scale: yes

# IfcFlowController: 150 mm, M_Ball Valve - 50-150 mm:150 mm:150 mm:1060602
In: 1E15
Type - ElementType: 150 mm
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Identity Data - Mark: 180
PSet_Revit_Dimensions - Size: 150 mmø-150 mmø
PSet_Revit_Constraints - Level: Level 1; Host: Level : Level 1; Offset: 2.985 m
PSet_Revit_Type_Mechanical - K Coefficient: 0.28
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Fire Protection Wet; System Name: Fire Protection; Loss Method: 5
PSet_Revit_Type_Other - Radius: 0.1425 m; Length 2: 0.06975 m; Length 1: 0.2232 m; Half Nut Height: 0.02475 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Dimensions - Stem Radius: 0.015 m; Stem Height: 0.0825 m; Stem Diameter: 0.03 m; Seal Length: 0.06975 m; Nut Radius: 0.0225 m; Nut Height: 0.0495 m; Nut Diameter: 0.045 m; Nominal Radius: 0.246063; Nominal Diameter: 0.492126; Handle Width: 0.051 m; Handle Length: 0.259 m; Handle Height: 0.66 m; Body Radius: 0.0825 m; Body Length: 0.279 m; Body Height: 0.2145 m; Body Diameter: 0.165 m; Adapter Radius: 0.12 m; Adapter Length: 0.0279 m; Adapter Diameter: 0.24 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.65.55.14.17; OmniClass Title: Adjusting/Controlling Valves for Liquid Services

# IfcFlowController: 20 mm, M_Backflow Preventer - 15-50 mm:20 mm:20 mm:1054811
In: 1D20
Type - ElementType: 20 mm
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Level: Level 2; Host: Level : Level 2; Offset: -1.35 m
PSet_Revit_Dimensions - Size: 20 mmø-20 mmø
PSet_Revit_Mechanical - Pressure Drop: 10717.7; System Type: Domestic Cold Water,Domestic Hot Water; System Name: Default Domestic Cold Water (cskender),Default Domestic Hot Water (cskender); Loss Method: 5
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.65.55.14.21; OmniClass Title: Non-Return Valves for Liquid Services
PSet_Revit_Type_Other - Width 2: 0.0054 m; Thickness 1: 0.003 m; Radius 9: 0.0048 m; Radius 8: 0.003 m; Radius 7: 0.0072 m; Radius 6: 0.027 m; Radius 5: 0.02565 m; Radius 4: 0.009 m; Radius 3: 0.0108 m; Radius 2: 0.0191 m; Radius 10: 0.02025 m; Radius 1: 0.0127 m; Outside Radius: 0.012 m; Length 9: 0.0105529 m; Length 8: 0.00150756 m; Length 7: 0.0180907 m; Length 6: 0.0120604 m; Length 5: 0.0482418 m; Length 4: 0.00603022 m; Length 3: 0.008125 m; Length 2: 0.0191 m; Length 1: 0.0325 m; Length: 0.120604 m; Height 6: 0.006 m; Height 5: 0.012 m; Height 4: 0.0018 m; Height 3: 0.0162 m; Height 2: 0.048 m; Height 1: 0.036 m; Angle 2: 45 deg; Angle 1: 45 deg; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Identity Data - Mark: 178
PSet_Revit_Type_Dimensions - Width 1: 0.027 m; Valve Length: 0.308 m; Outside Diameter: 0.024 m; Open Height: 0.127 m; Nominal Radius: 0.0328084; Nominal Diameter: 0.0656168; C1 Offset 2: 0.052 m; C1 Offset 1: 0.089 m; Body Length: 0.195 m

# IfcFlowController: 50 mm (167)
Type - ElementType: 50 mm
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Loss Method: 5
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Dimensions - Size: 50 mmø-50 mmø
PSet_Revit_Type_Other - Radius: 0.092 m; Length 2: 0.0445 m; Length 1: 0.1424 m; Half Nut Height: 0.00825 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.65.55.14.17; OmniClass Title: Adjusting/Controlling Valves for Liquid Services
PSet_Revit_Type_Dimensions - Stem Radius: 0.005 m; Stem Height: 0.0275 m; Stem Diameter: 0.01 m; Seal Length: 0.0445 m; Nut Radius: 0.0075 m; Nut Height: 0.0165 m; Nut Diameter: 0.015 m; Nominal Radius: 0.082021; Nominal Diameter: 0.164042; Handle Width: 0.025 m; Handle Length: 0.127 m; Handle Height: 0.229 m; Body Radius: 0.0275 m; Body Length: 0.178 m; Body Height: 0.0715 m; Body Diameter: 0.055 m; Adapter Radius: 0.04 m; Adapter Length: 0.0178 m; Adapter Diameter: 0.08 m
PSet_Revit_Type_Mechanical - K Coefficient: 0.35
Name (M_Ball Valve - 50-150 mm:50 mm:50 mm:...) | In | System Type | System Name | Level | Host | Offset (m) | Mark
719540 | 1A05 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 171
715036 | 1D10 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 149
714202 | 1D10 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 148
678388 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 3
706911 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 113
719742 | 1D12 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 172
715385 | 1D10 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 150
719068 | 1A16 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 167
677946 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 2
711687 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 138
711661 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 137
713299 | 1B04 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.43 | 144
716433 | 1C15 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 153
690351 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 56
710478 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 130
707522 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 115
709817 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.25 | 127
719283 | 1A05 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.45 | 169
704564 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 103
685393 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 31
709693 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 126
719506 | 1A05 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.45 | 170
707065 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 114
705334 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.25 | 104
716909 | 1C01 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 156
719098 | 1A16 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.35 | 168
713141 | 1B11 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.43 | 143
685898 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 33
685574 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 32
686685 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 35
712897 | 1B03 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 141
689452 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 49
714024 | 1E33 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 146
712254 | Level 1 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 139
715801 | 1C15 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 151
710192 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 128
708079 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 118
690249 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 55
711105 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 133
690000 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 53
713103 | 1B11 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 142
704462 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 101
698108 | 1D10 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 76
680360 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 13
702761 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 93
684566 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 27
717219 | 1C02 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 158
708296 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 119
686477 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 34
706260 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 109
717359 | 1C10 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 159
710893 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 132
682634 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 22
705349 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.25 | 105
683963 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 25
710727 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 131
687167 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 38
716496 | 1C13 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.35 | 154
716696 | Level 1 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 155
681993 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 21
717082 | 1C02 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 157
689214 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 47
681789 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 20
690481 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 57
700687 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 82
707830 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 117
706121 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 108
680866 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 16
684108 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 26
684928 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 29
679158 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 9
707723 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.25 | 116
712867 | 1B03 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 140
706564 | 1BC2 | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | 0.3 | 111
706649 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 112
704116 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 98
717486 | 1C10 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 160
705714 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.25 | 106
690120 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 54
711462 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 135
713414 | 1B10 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.5 | 145
708509 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 120
681608 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 19
703964 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 97
687890 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 40
689734 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 51
687064 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 37
683673 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 24
709176 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 124
704549 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 102
692504 | 1B05 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 59
685092 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 30
705930 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.25 | 107
678902 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 6
714079 | 1E33 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.35 | 147
715978 | 1C13 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 152
709391 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 125
688106 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 41
700570 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 81
688479 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 43
686819 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 36
704298 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 99
680512 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 14
695343 | 1C07 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 68
703645 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 95
696720 | 1AC3 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 71
695191 | 1C10 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 66
711436 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 134
717822 | 1C07 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 162
694543 | 1C13 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 63
679912 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 11
710344 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 129
703318 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 94
689789 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 52
691415 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 58
688995 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 46
704348 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 100
699794 | 1C15 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 78
701822 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 89
680142 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 12
692987 | 1B04 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 60
682810 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 23
718479 | 1C07 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 163
697331 | 1A05 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 75
706502 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 110
684733 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 28
680955 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 17
703675 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.35 | 96
679734 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 10
718781 | 1A12 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 165
687717 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 39
718977 | Level 1 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 166
711495 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 136
701192 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 83
701674 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.35 | 87
689335 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 48
678780 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 5
695522 | 1C07 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 69
681320 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 18
688819 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 45
697150 | 1A16 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 74
701697 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 88
718612 | 1AC3 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 164
701632 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 86
694243 | 1C15 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 62
678985 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 7
701325 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 84
688237 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 42
699081 | 1C07 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 77
708869 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 122
695214 | 1C10 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 67
693699 | 1E33 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 61
696843 | 1A12 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 72
694960 | 1C02 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 65
694756 | 1C01 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 64
701542 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 85
702027 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 90
717694 | 1C07 | Domestic Hot Water | Domestic Hot Water 1 | Level 2 | Level : Level 2 | -1.4 | 161
702315 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 92
700016 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 79
696961 | Level 1 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 73
700230 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 80
696516 | 1AC3 | Domestic Cold Water | Domestic Cold Water 1 | Level 2 | Level : Level 2 | -1.5 | 70
678544 | TOF Footing | Domestic Cold Water | Domestic Cold Water 1 | Level 1 | Level : Level 1 | -0.4 | 4
708968 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 123
708618 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 121
702042 | TOF Footing | Domestic Hot Water | Domestic Hot Water 1 | Level 1 | Level : Level 1 | -0.3 | 91

# IfcFlowController: 65 mm (2)
In: 1D20
Type - ElementType: 65 mm
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Loss Method: 5
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 65 mmø-65 mmø
PSet_Revit_Constraints - Level: Level 2; Host: Level : Level 2
PSet_Revit_Type_Other - Radius: 0.0985 m; Length 2: 0.04775 m; Length 1: 0.1528 m; Half Nut Height: 0.010725 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.65.55.14.17; OmniClass Title: Adjusting/Controlling Valves for Liquid Services
PSet_Revit_Type_Dimensions - Stem Radius: 0.0065 m; Stem Height: 0.03575 m; Stem Diameter: 0.013 m; Seal Length: 0.04775 m; Nut Radius: 0.00975 m; Nut Height: 0.02145 m; Nut Diameter: 0.0195 m; Nominal Radius: 0.106627; Nominal Diameter: 0.213255; Handle Width: 0.0381 m; Handle Length: 0.14 m; Handle Height: 0.406 m; Body Radius: 0.03575 m; Body Length: 0.191 m; Body Height: 0.09295 m; Body Diameter: 0.0715 m; Adapter Radius: 0.052 m; Adapter Length: 0.0191 m; Adapter Diameter: 0.104 m
PSet_Revit_Type_Mechanical - K Coefficient: 0.32
Name (M_Ball Valve - 50-150 mm:65 mm:65 mm:...) | Mark | System Type | System Name | Offset (m)
1054735 | 176 | Domestic Hot Water | Domestic Hot Water 1 | -1.4
1054726 | 175 | Domestic Cold Water | Domestic Cold Water 1 | -1.5

# IfcFlowController: 80 mm, M_Ball Valve - 50-150 mm:80 mm:80 mm:688571
In: TOF Footing
Type - ElementType: 80 mm
PSet_Revit_Type_Dimensions - Stem Radius: 0.008 m; Stem Height: 0.044 m; Stem Diameter: 0.016 m; Seal Length: 0.05075 m; Nut Radius: 0.012 m; Nut Height: 0.0264 m; Nut Diameter: 0.024 m; Nominal Radius: 0.131234; Nominal Diameter: 0.262467; Handle Width: 0.038 m; Handle Length: 0.159 m; Handle Height: 0.406 m; Body Radius: 0.044 m; Body Length: 0.203 m; Body Height: 0.1144 m; Body Diameter: 0.088 m; Adapter Radius: 0.064 m; Adapter Length: 0.0203 m; Adapter Diameter: 0.128 m
PSet_Revit_Type_Other - Radius: 0.1045 m; Length 2: 0.05075 m; Length 1: 0.1624 m; Half Nut Height: 0.0132 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.65.55.14.17; OmniClass Title: Adjusting/Controlling Valves for Liquid Services
PSet_Revit_Type_Mechanical - K Coefficient: 0.31
PSet_Revit_Dimensions - Size: 80 mmø-80 mmø
PSet_Revit_Constraints - Level: Level 1; Host: Level : Level 1; Offset: -0.4 m
PSet_Revit_Identity Data - Mark: 44
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Loss Method: 5
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier

# IfcFlowFitting: 1 D (113)
Type - ElementType: 1 D
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Lining Thickness: 0; Insulation Thickness: 0; System Type: Supply Air; Loss Method: 1
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.14; OmniClass Title: Air Ductwork
PSet_Revit_Type_Dimensions - Radius Multiplier: 1
Name (M_Round Elbow:1 D:1 D:...) | In | Mark | Radius = Lining Radius = Insulation Radius | Length1 | Center Radius | Angle (deg) | Size | System Name | Level | Host | Offset (m) | ASHRAE Table
569552 | 2DC1 | 7252 | 0.656168 | 0.0146655 | 1.31234 | 1.28052 | 400ø-400ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0895
569897 | 2B11 | 8180 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33
569488 | 2A11 | 7056 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-11
569830 | 2D07 | 8012 | 0.410105 | 0.258611 | 0.82021 | 35 | 250ø-250ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.2705
569883 | 2B9 | 8153 | 0.246063 | 0.159901 | 0.492126 | 36 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705
569907 | 2BC6 | 8197 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08
569553 | 2D01 | 7254 | 0.656168 | 0.0146655 | 1.31234 | 1.28052 | 400ø-400ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08
569908 | 2BC6 | 8199 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33
569533 | 2BC3 | 7216 | 0.328084 | 0.655903 | 0.656168 | 89.9769 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08
569507 | 2A13 | 7161 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-11
569834 | 2D06 | 8014 | 0.410105 | 0.339742 | 0.82021 | 45 | 250ø-250ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.2705 | CD3-17
569838 | 2BC5 | 8026 | 0.328084 | 0.656557 | 0.656168 | 90.0339 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08
569462 | 2A14 | 6968 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-11
569833 | Level 2 | 8013 | 0.410105 | 0.258611 | 0.82021 | 35 | 250ø-250ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.2705
569348 | 2C08 | 6699 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-17
569365 | 2C19 | 6746 | 0.410105 | 0.339742 | 0.82021 | 45 | 250ø-250ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.38952
569742 | 2D18 | 7786 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-11
569328 | 2C03 | 6633 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33 | CD3-11
569224 | 2C17 | 6336 | 0.492126 | 0.984252 | 0.984252 | 90 | 300ø-300ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.27048 | CD3-11
569733 | 2D18 | 7761 | 0.328084 | 0.655826 | 0.656168 | 89.9701 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08
569788 | 2D18 | 7894 | 0.328084 | 0.656609 | 0.656168 | 90.0385 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08
568423 | 1B04 | 5205 | 0.574147 | 0.314568 | 1.14829 | 30.6399 | 350ø-350ø | Mechanical Supply Air 1 | Level 2 | Level : Level 2 | -0.88
569885 | 2B9 | 8156 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33 | CD3-17
569491 | 2A11 | 7071 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33 | CD3-17
569410 | 2A14 | 6824 | 0.410105 | 0.82021 | 0.82021 | 90 | 250ø-250ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08 | CD3-11
569540 | 2BC3 | 7223 | 0.410105 | 0.0173078 | 0.82021 | 2.41772 | 250ø-250ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08948
569510 | 2A13 | 7167 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-17
569473 | 2A08 | 7031 | 0.492126 | 0.984252 | 0.984252 | 90 | 300ø-300ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-11
569555 | 2D02 | 7265 | 0.656168 | 1.31234 | 1.31234 | 90 | 400ø-400ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08 | CD3-11
569349 | 2C08 | 6701 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33 | CD3-17
569896 | 2B11 | 8178 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705
569326 | 2C03 | 6627 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33 | CD3-17
569511 | 2A13 | 7174 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33 | CD3-17
569315 | 2AC2 | 6608 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33 | CD3-11
567486 | 1BC2 | 2238 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Mechanical Supply Air 1 | Level 1 | Level : Level 1 | 3.69 | CD3-11
569776 | 2D19 | 7862 | 0.410105 | 0.219775 | 0.82021 | 30 | 250ø-250ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-18
569500 | 2A13 | 7142 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-17
569887 | 2B9 | 8164 | 0.246063 | 0.250751 | 0.492126 | 54 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33
569756 | 2D21 | 7813 | 0.410105 | 0.339742 | 0.82021 | 45 | 250ø-250ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08 | CD3-17
569309 | 2AC2 | 6596 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705
569688 | 2BC2 | 7599 | 0.328084 | 0.271794 | 0.656168 | 45 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33 | CD3-17
569364 | Level 2 | 6742 | 0.410105 | 0.339742 | 0.82021 | 45 | 250ø-250ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08
569774 | 2D17 | 7857 | 0.410105 | 0.219775 | 0.82021 | 30 | 250ø-250ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-18
569490 | 2A11 | 7064 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-17
569902 | 2B11 | 8193 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33 | CD3-11
569351 | 2C08 | 6706 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33 | CD3-11
569703 | 2D04 | 7680 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-11
569375 | 2CC1 | 6756 | 0.328084 | 0.271794 | 0.656168 | 45 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08 | CD3-17
569627 | 2BC4 | 7465 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-17
569320 | 2AC2 | 6613 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Mechanical Supply Air 2 | Level 2 | Level : Level 2 | 3.6095 | CD3-11
569610 | 2BC3 | 7426 | 0.410105 | 0.0173078 | 0.82021 | 2.41772 | 250ø-250ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08
569470 | 2A07 | 7025 | 0.492126 | 0.984252 | 0.984252 | 90 | 300ø-300ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-11
569231 | 2C12 | 6354 | 0.410105 | 0.323089 | 0.82021 | 43 | 250ø-250ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.28
569854 | 2BC5 | 8075 | 0.410105 | 0.82021 | 0.82021 | 90 | 250ø-250ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-11
569501 | 2A13 | 7149 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33 | CD3-17
568397 | 1E06 | 5152 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Mechanical Supply Air 1 | Level 2 | Level : Level 2 | -0.770525 | CD3-11
569811 | 2D13 | 7946 | 0.328084 | 0.655733 | 0.656168 | 89.962 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.28
569884 | 2B9 | 8154 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-17
568422 | 1B04 | 5203 | 0.574147 | 1.14829 | 1.14829 | 90 | 350ø-350ø | Mechanical Supply Air 1 | Level 1 | Level : Level 1 | 3.69 | CD3-11
569228 | 2C12 | 6351 | 0.410105 | 0.323089 | 0.82021 | 43 | 250ø-250ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.28
569807 | 2D18 | 7944 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.27052 | CD3-11
569634 | 2BC4 | 7481 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-11
569901 | 2BC6 | 8191 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 2 | Level 2 | Level : Level 2 | 3.35 | CD3-11
569355 | 2C07 | 6721 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-11
569424 | 2A05 | 6854 | 0.328084 | 0.655855 | 0.656168 | 89.9726 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08
569310 | 2AC2 | 6598 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33
569209 | 2C14 | 6264 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.27049 | CD3-11
568394 | 1E06 | 5144 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Mechanical Supply Air 1 | Level 1 | Level : Level 1 | 3.79948 | CD3-11
569631 | 2BC4 | 7472 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.33 | CD3-17
569325 | 2C03 | 6625 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-17
569687 | 2BC2 | 7597 | 0.328084 | 0.271794 | 0.656168 | 45 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-17
569747 | 2D18 | 7800 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-17
569660 | 2B14 | 7534 | 0.246063 | 0.492126 | 0.492126 | 90 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0455 | CD3-11
569183 | 2C17 | 6205 | 0.410105 | 0.81974 | 0.82021 | 89.9672 | 250ø-250ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.28
569845 | 2B3 | 8040 | 0.492126 | 0.984252 | 0.984252 | 90 | 300ø-300ø | Mechanical Supply Air 2 | Level 2 | Level : Level 2 | 3.6095 | CD3-11
569302 | 2C02 | 6575 | 0.492126 | 0.984252 | 0.984252 | 90 | 300ø-300ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0705 | CD3-11
569760 | 2D20 | 7827 | 0.492126 | 0.984252 | 0.984252 | 90 | 300ø-300ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.08 | CD3-11
569661 | 2B14 | 7535 | 0.246063 | 0.203845 | 0.492126 | 45 | 150ø-150ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.0455 | CD3-17
1107632 | 1A16 | 455 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Mechanical Supply Air 1 | Level 1 | Level : Level 1 | 3.7095 | CD3-11
568413 | 1B13 | 5181 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Mechanical Supply Air 1 | Level 2 | Level : Level 2 | -0.770484 | CD3-11
569727 | 2DC2 | 7744 | 0.328084 | 0.656168 | 0.656168 | 90 | 200ø-200ø | Mechanical Supply Air 2 | Roof - Main | Level : Roof - Main | -1.48 | CD3-11
