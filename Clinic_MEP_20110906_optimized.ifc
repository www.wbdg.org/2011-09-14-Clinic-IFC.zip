Properties of the parts of a building model (IFC2X3), part 1 of 295

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2011-09-06T16:36:26
Written by: Autodesk Revit MEP 2011 - 1.0
Made in: 20100326_1700 (Solibri IFC Optimizer)

# IfcProject, Project Number
Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 m

# IfcBuilding
PSet_Revit_Other - Project Issue Date: Issue Date; Project Status: Project Status; Client Name: Owner; Project Address: Enter address here; Project Name: Project Name; Project Number: Project Number; Category Description: OmniClass Table 11 Description; Category Code: OmniClass Table 11 Code
Pset_BuildingCommon - NumberOfStoreys: 4

# IfcBuildingStorey (4)
PSet_Revit_Other - Category Code: Floor
PSet_Revit_Type_Graphics - Line Weight: 1; Color: 0; Line Pattern: Centre; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
PSet_Revit_Type_Constraints - Elevation Base: 0
PSet_Revit_Type_Dimensions - Automatic Room Computation Height: no; Computation Height: 1.2 m
Name | Elevation (m) | Name | PSet_Revit_Constraints, Elevation (m)
Roof - Main | 9.25 | Roof - Main | 9.25
Level 1 | -2.82087e-13 | Level 1 | 0
Level 2 | 4.57 | Level 2 | 4.57
TOF Footing | -1 | TOF Footing | -1

# IfcSpace (526)
InteriorOrExteriorSpace: INTERNAL
PSet_Revit_Phasing - Phase: New Construction
Name | In | LongName = Name | Area (m2) = GSA BIM Area (m2) | Perimeter (m) | Unbounded Height (m) | Volume (m3) | Level | Upper Limit | Limit Offset (m) | Base Offset (m) | Category Description | Category Code | CirculationZoneName | FireAlarmZoneName | HistoricPreservationZoneName | LightingZoneName | OccupancyZoneName | VentilationZoneName | Number | OmniClass Table 13 Category | RoomTag
1D04-M | Level 1 | TOILET | 4.58078 | 8.592 | 4 | 18.3231 | Level 1 | Level 1 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D04-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 8.9938; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D04; Room Name: TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D02-M | Level 1 | INTERACTION STATION | 10.7208 | 13.402 | 4 | 42.883 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D02-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.99422; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D02; Room Name: INTERACTION STATION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1C12-M | Level 1 | TOILET | 5.4587 | 9.4895 | 4 | 21.8348 | Level 1 | Level 1 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C12-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 8.33572; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C12; Room Name: TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1C14-M | Level 1 | HIST. / INTV | 7.31109 | 10.87 | 4 | 29.2444 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C14-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.12912; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C14; Room Name: HIST. / INTV.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1A03-M | Level 1 | TRICARE OFFICE | 8.15852 | 11.531 | 4 | 32.6341 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A03-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.77711; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1A03; Room Name: TRICARE OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D20-M | Level 2 | CONF. ROOM | 29.3554 | 21.8574 | 4 | 117.421 | Level 2 | Level 2 | 4 | 0 | Conference Room | 13-11 21 17 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D20-M | 13-11 21 17: Conference Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 3.57026; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D20; Room Name: CONF. ROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1AC3-M | Level 1 | CORRIDOR | 15.0083 | 21.1395 | 4 | 60.0334 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1AC3-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.75383; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1AC3; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C07-M | Level 2 | M. STAFF TOILET | 16.4631 | 26.4508 | 4 | 65.8525 | Level 2 | Level 2 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C07-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.82448; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C07; Room Name: M. STAFF TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C03-M | Level 2 | CONSULT. | 31.9369 | 28.6123 | 4 | 127.748 | Level 2 | Level 2 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C03-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 24.8968; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.29584; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C03; Room Name: CONSULT.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2AC1-M | Level 2 | CORRIDOR | 38.89 | 30.3018 | 4 | 155.562 | Level 2 | Level 2 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2AC1-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 3.73611; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2AC1; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1A10-M | Level 1 | LOUNGE | 9.51917 | 13.954 | 4 | 38.0767 | Level 1 | Level 1 | 4 | 0 | Break Room | 13-51 11 21 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A10-M | 13-51 11 21: Break Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.02892; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1A10; Room Name: LOUNGE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D12-M | Level 1 | SPECIMEN COLL. LAB | 9.42752 | 12.6769 | 4 | 37.7101 | Level 1 | Level 1 | 4 | 0 | Laboratory | 13-15 11 24 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D12-M | 13-15 11 24 11: Laboratory | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.44769; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D12; Room Name: SPECIMEN COLL. LAB; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C15-M | Level 2 | COMM. ROOM | 8.82326 | 12.034 | 4 | 35.293 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C15-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 0; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C15; Room Name: COMM. ROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C05-M | Level 2 | JAN. CL. | 3.23709 | 7.768 | 4 | 12.9484 | Level 2 | Level 2 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C05-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 0; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C05; Room Name: JAN. CL.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B11-M | Level 2 | WAITING | 9.52495 | 12.66 | 4 | 38.0998 | Level 2 | Level 2 | 4 | 0 | Waiting Room | 13-51 31 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B11-M | 13-51 31 11: Waiting Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.37326; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B11; Room Name: WAITING; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D05-M | Level 1 | TRMT RM. DIRTY PROC. | 13.4313 | 14.6785 | 4 | 53.7253 | Level 1 | Level 1 | 4 | 0 | Treatment Room | 13-41 41 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D05-M | 13-41 41 11: Treatment Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.24023; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D05; Room Name: TRMT RM. DIRTY PROC.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1C03-M | Level 1 | JAN. CL. | 3.54682 | 8.384 | 4 | 14.1873 | Level 1 | Level 1 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C03-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 11.3345; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C03; Room Name: JAN. CL.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D36-M | Level 1 | INTERACTION STATION | 11.8534 | 13.936 | 4 | 47.4137 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D36-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.63745; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D36; Room Name: INTERACTION STATION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D10-M | Level 1 | INTERACTION STATION | 11.8839 | 13.9369 | 4 | 47.5354 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D10-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.62338; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D10; Room Name: INTERACTION STATION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D34-M | Level 1 | INTERACTION STATION | 11.9464 | 13.936 | 4 | 47.7856 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D34-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.59357; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D34; Room Name: INTERACTION STATION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2BC3-M | Level 2 | CORRIDOR | 24.923 | 32.5119 | 4 | 99.6922 | Level 2 | Level 2 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2BC3-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.25503; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2BC3; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D40-M | Level 1 | IMMUNIZ'N ROOM | 15.3999 | 18.822 | 4 | 61.5995 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D40-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.86053; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: Unoccupied; Room Name: Unoccupied; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2CC1-M | Level 2 | CORRIDOR | 17.4182 | 23.8522 | 4 | 69.6728 | Level 2 | Level 2 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2CC1-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.56619; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2CC1; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B10-M | Level 2 | RECEPTION | 14.1815 | 16.199 | 4 | 56.7258 | Level 2 | Level 2 | 4 | 0 | Reception Space | 13-11 11 31 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B10-M | 13-11 11 31: Reception Space | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.47717; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B10; Room Name: RECEPTION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1AC5-M | Level 1 | CORRIDOR | 19.2192 | 32.584 | 4 | 76.8768 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1AC5-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 8.12939; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1AC5; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1A07-M | Level 1 | TRICARE OFFICE | 7.96938 | 11.8885 | 4 | 31.8775 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A07-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.15305; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1A07; Room Name: TRICARE OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E17-M | Level 1 | HAZ. STOR. | 8.65657 | 10.2441 | 4 | 34.6263 | Level 1 | Level 1 | 4 | 0 | Hazardous Material Storage Space | 13-75 41 24 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E17-M | 13-75 41 24: Hazardous Material Storage Space | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.67435; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: Unoccupied; Room Name: Unoccupied; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B10-M | Level 1 | STAFF LOUNGE | 9.40654 | 13.01 | 4 | 37.6261 | Level 1 | Level 1 | 4 | 0 | Break Room | 13-51 11 21 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B10-M | 13-51 11 21: Break Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.63187; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B10; Room Name: STAFF LOUNGE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1C10-M | Level 1 | OPT. EXAM / OFF. | 16.9814 | 20.4428 | 4 | 67.9256 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C10-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.77238; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C10; Room Name: OPT. EXAM / OFF.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C23-M | Level 2 | M. TOILET | 7.66403 | 12.6107 | 4 | 30.6561 | Level 2 | Level 2 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C23-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.88988; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C23; Room Name: M. TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D03-M | Level 1 | CLEAN U. | 2.08844 | 6.012 | 4 | 8.35376 | Level 1 | Level 1 | 4 | 0 | Clean Room | 13-15 21 11 21 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D03-M | 13-15 21 11 21: Clean Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 0; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D03; Room Name: CLEAN U.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C08-M | Level 2 | STAFF TOILET | 14.2717 | 21.304 | 4 | 57.0867 | Level 2 | Level 2 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C08-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.26967; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C08; Room Name: W. STAFF TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1A13-M | Level 1 | STAFF TOILET | 3.93739 | 8.01 | 4 | 15.7495 | Level 1 | Level 1 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A13-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 9.75469; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1A13; Room Name: STAFF TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1A06-M | Level 1 | TRICARE OFFICE | 9.3277 | 12.2445 | 4 | 37.3108 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A06-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.29441; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1A06; Room Name: TRICARE OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D08-M | Level 1 | INTERACTION STATION | 11.9478 | 13.9369 | 4 | 47.7912 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D08-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.59329; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D08; Room Name: INTERACTION STATION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B06-M | Level 1 | LAB OFFICE | 9.35111 | 12.4779 | 4 | 37.4045 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B06-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.39836; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B06; Room Name: LAB OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1A12-M | Level 1 | M. TOILET | 9.14694 | 12.644 | 4 | 36.5877 | Level 1 | Level 1 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A12-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.62823; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1A12; Room Name: M. TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D21-M | Level 1 | GROUP IS | 17.9225 | 17.522 | 4 | 71.6901 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D21-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.68784; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D21; Room Name: GROUP IS; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D12-M | Level 2 | VEST. | 2.32692 | 6.34788 | 4 | 9.3077 | Level 2 | Level 2 | 4 | 0 | Entry Vestibule | 13-85 31 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D12-M | 13-85 31 11: Entry Vestibule | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 13.0808; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D12; Room Name: VEST.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B12-M | Level 2 | COMM. ROOM | 9.1322 | 12.659 | 4 | 36.5288 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B12-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.64678; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B12; Room Name: COMM. ROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2BC4-M | Level 2 | CORRIDOR | 11.5469 | 16.8314 | 4 | 46.1878 | Level 2 | Level 2 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2BC4-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.98944; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2BC4; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2CC5-M | Level 2 | CORRIDOR | 7.41772 | 12.26 | 4 | 29.6709 | Level 2 | Level 2 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2CC5-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.92517; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2CC5; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C14-M | Level 2 | GEN. DENT. DTR #10 | 11.044 | 13.482 | 4 | 44.1759 | Level 2 | Level 2 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C14-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.85353; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C14; Room Name: GEN. DENT. DTR #10; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2DC2-M | Level 2 | CORRIDOR | 28.3759 | 36.2198 | 4 | 113.504 | Level 2 | Level 2 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2DC2-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.12048; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2DC2; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1A02-M | Level 1 | RMO ANALYST | 26.6578 | 25.85 | 4 | 106.631 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A02-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 24.8968; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.64969; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1A02; Room Name: RMO ANALYST; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D01-M | Level 1 | SL. LIN. / TRASH | 1.66233 | 5.6969 | 4 | 6.64934 | Level 1 | Level 1 | 4 | 0 | Soiled Storage Room Space | 13-75 41 14 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D01-M | 13-75 41 14: Soiled Storage Room Space | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 16.4327; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D01; Room Name: SL. LIN. / TRASH; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D05-M | Level 2 | MAIN MECHANICAL ROOM | 226.043 | 64.293 | 4 | 904.173 | Level 2 | Level 2 | 4 | 0 | Mechanical Room | 13-81 21 17 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D05-M | 13-81 21 17: Mechanical Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 0; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D05; Room Name: MAIN MECHANICAL ROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E09-M | Level 1 | W. TOILET | 4.4482 | 8.666 | 4 | 17.7928 | Level 1 | Level 1 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E09-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 9.34163; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E09; Room Name: W. TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1CC3-M | Level 1 | CORRIDOR | 10.6082 | 16.1832 | 4 | 42.4326 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1CC3-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.31499; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1CC3; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1A15-M | Level 1 | COUNSELING | 5.86803 | 9.731 | 4 | 23.4721 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A15-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.95158; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1A15; Room Name: COUNSELING; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B3-M | Level 2 | CONF. / GROUP THERAPY | 17.8984 | 18.8676 | 4 | 71.5937 | Level 2 | Level 2 | 4 | 0 | Conference Room | 13-11 21 17 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B3-M | 13-11 21 17: Conference Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.05465; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B3; Room Name: CONF. / GROUP THERAPY; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B14-M | Level 1 | SOIL. UTL. | 3.42762 | 7.97 | 4 | 13.7105 | Level 1 | Level 1 | 4 | 0 | Soiled Storage Room Space | 13-75 41 14 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B14-M | 13-75 41 14: Soiled Storage Room Space | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 11.1495; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B14; Room Name: SOIL. UTL.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C10-M | Level 2 | DIPC DECON | 10.2499 | 12.996 | 4 | 40.9996 | Level 2 | Level 2 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C10-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.07965; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C10; Room Name: DIPC DECON; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D27-M | Level 1 | ADMIN WORK STATN. | 9.95831 | 12.916 | 4 | 39.8332 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D27-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.21915; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D27; Room Name: ADMIN WORK STATN.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E15-A-M | Level 1 | GAS STORAGE | 1.65758 | 6.6616 | 4 | 6.6303 | Level 1 | Level 1 | 4 | 0 | Mechanical Room | 13-81 21 17 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E15-A-M | 13-81 21 17: Mechanical Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 0; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E15-A; Room Name: GAS STORAGE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
