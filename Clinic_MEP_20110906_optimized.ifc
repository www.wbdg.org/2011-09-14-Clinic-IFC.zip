Properties of the parts of a building model (IFC2X3), part 6 of 295

# IfcSpace (526)
Name | In | LongName = Name | Area (m2) = GSA BIM Area (m2) | Perimeter (m) | Unbounded Height (m) | Volume (m3) | Level | Upper Limit | Limit Offset (m) | Base Offset (m) | Category Description | Category Code | CirculationZoneName | FireAlarmZoneName | HistoricPreservationZoneName | LightingZoneName | OccupancyZoneName | VentilationZoneName | Number | OmniClass Table 13 Category | RoomTag
2A11 | Level 2 | DENTAL WAITING | 33.4834 | 29.0513 | 4.68 | 149.032 | Level 2 | Roof - Main | 0 | 0 | Waiting Room | 13-51 31 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A11 | 13-51 31 11: Waiting Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D04-A | Level 2 | COMPUTER ROOM | 33.5478 | 23.6075 | 4.68 | 150.137 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D04-A | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D21 | Level 2 | LIBRARY / CLASSROOM | 27.3034 | 21.2805 | 4.68 | 123.751 | Level 2 | Roof - Main | 0 | 0 | Classroom | 13-11 11 17 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D21 | 13-11 11 17: Classroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D04 | Level 2 | SYS. ANALYST | 20.7007 | 19.9515 | 4.68 | 90.9847 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D04 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D39 | Level 1 | JAN. CL. | 2.00067 | 6.192 | 4.57 | 7.59276 | Level 1 | Level 2 | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D39 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D14 | Level 2 | OPS SQUAD CMDR | 13.6001 | 15.4428 | 4.68 | 59.5061 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D14 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B11 | Level 1 | STAFF TOILET | 4.99399 | 8.996 | 4.57 | 20.1557 | Level 1 | Level 2 | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B11 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B12 | Level 2 | COMM. ROOM | 9.92484 | 13.085 | 4.68 | 42.7387 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B12 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1EC2 | Level 1 | CORRIDOR | 7.91371 | 11.7164 | 4.57 | 33.2359 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1EC2 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1A02 | Level 1 | RMO ANALYST | 27.6932 | 26.5002 | 4.57 | 121.826 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A02 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1DC8 | Level 1 | CORRIDOR | 6.29243 | 10.6091 | 4.57 | 26.8663 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1DC8 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C13 | Level 2 | TRASH | 5.53953 | 10.182 | 4.68 | 23.3475 | Level 2 | Roof - Main | 0 | 0 | Soiled Storage Room Space | 13-75 41 14 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C13 | 13-75 41 14: Soiled Storage Room Space | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2CC1 | Level 2 | CORRIDOR | 18.813 | 23.5826 | 4.68 | 81.5171 | Level 2 | Roof - Main | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2CC1 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D20 | Level 2 | CONF. ROOM | 30.712 | 22.3024 | 4.68 | 137.383 | Level 2 | Roof - Main | 0 | 0 | Conference Room | 13-11 21 17 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D20 | 13-11 21 17: Conference Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B6 | Level 2 | STAFF TOILET | 5.65351 | 9.636 | 4.68 | 23.4593 | Level 2 | Roof - Main | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B6 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D15 | Level 2 | 1ST SGT | 10.8297 | 13.588 | 4.68 | 46.4509 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D15 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2A04 | Level 2 | DENTAL SURGEON OFFICE | 16.0139 | 16.099 | 4.68 | 69.882 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A04 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1EC3 | Level 1 | CORRIDOR | 8.75185 | 12.6304 | 4.57 | 36.8072 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1EC3 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D31 | Level 1 | PEDIATRIC WTS & MSRS | 11.0208 | 13.719 | 4.57 | 46.6988 | Level 1 | Level 2 | 0 | 0 | Physical Examination Room | 13-41 41 14 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D31 | 13-41 41 14: Physical Examination Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1C12 | Level 1 | TOILET | 6.14704 | 10.0295 | 4.57 | 24.9462 | Level 1 | Level 2 | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C12 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E19 | Level 1 | ELEC. ROOM | 9.6262 | 12.686 | 4.57 | 40.6186 | Level 1 | Level 2 | 0 | 0 | Electrical Room | 13-81 21 21 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E19 | 13-81 21 21: Electrical Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E15 | Level 1 | CENTRAL MECH. RM. | 28.9142 | 24.1165 | 4.57 | 124.109 | Level 1 | Level 2 | 0 | 0 | Mechanical Room | 13-81 21 17 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E15 | 13-81 21 17: Mechanical Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1C02 | Level 1 | RECEPTION | 9.31934 | 12.2052 | 4.57 | 40.3012 | Level 1 | Level 2 | 0 | 0 | Reception Space | 13-11 11 31 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C02 | 13-11 11 31: Reception Space | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C18 | Level 2 | ELECTRICAL | 9.84 | 12.56 | 4.68 | 42.4788 | Level 2 | Roof - Main | 0 | 0 | Electrical Room | 13-81 21 21 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C18 | 13-81 21 21: Electrical Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E26 | Level 1 | WORK ROOM | 19.7143 | 18.857 | 4.57 | 83.8395 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E26 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C02 | Level 2 | GEN. DENT. DTR #6 | 12.0034 | 12.4022 | 4.68 | 51.985 | Level 2 | Roof - Main | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C02 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E03 | Level 1 | JAN. CL. | 3.96995 | 8.652 | 4.57 | 15.8496 | Level 1 | Level 2 | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E03 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E29 | Level 1 | HK. SUPV. OFFICE | 11.0301 | 13.469 | 4.57 | 45.4695 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E29 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2BC4 | Level 2 | CORRIDOR | 12.4825 | 16.6806 | 4.68 | 54.0397 | Level 2 | Roof - Main | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2BC4 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B11 | Level 2 | WAITING | 10.1069 | 12.908 | 4.68 | 44.5767 | Level 2 | Roof - Main | 0 | 0 | Waiting Room | 13-51 31 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B11 | 13-51 31 11: Waiting Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C24 | Level 2 | W. TOILET | 9.22003 | 12.1502 | 4.68 | 39.7625 | Level 2 | Roof - Main | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C24 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B19 | Level 1 | RADIOGRAPHIC ROOM | 29.9132 | 28.5508 | 4.57 | 129.023 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B19 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B23 | Level 1 | ELEC. ROOM | 9.88297 | 13.0801 | 4.57 | 41.5293 | Level 1 | Level 2 | 0 | 0 | Electrical Room | 13-81 21 21 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B23 | 13-81 21 21: Electrical Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1A10 | Level 1 | LOUNGE | 10.2725 | 14.38 | 4.57 | 43.5026 | Level 1 | Level 2 | 0 | 0 | Break Room | 13-51 11 21 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A10 | 13-51 11 21: Break Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1C07 | Level 1 | OPT. EXAM / OFF. | 17.5712 | 20.7032 | 4.57 | 74.5046 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C07 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E06 | Level 1 | TECH. WORK STATION | 37.3792 | 24.978 | 4.57 | 163.958 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E06 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2A05 | Level 2 | OH DTR #1 | 11.3331 | 11.5316 | 4.68 | 49.1916 | Level 2 | Roof - Main | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A05 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B05 | Level 1 | PAT. / STAFF TOILET | 4.78883 | 8.832 | 4.57 | 19.2728 | Level 1 | Level 2 | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B05 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B3 | Level 2 | CONF. / GROUP THERAPY | 19.2831 | 19.7196 | 4.68 | 83.7647 | Level 2 | Roof - Main | 0 | 0 | Conference Room | 13-11 21 17 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B3 | 13-11 21 17: Conference Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1C06 | Level 1 | SOIL. UTL. / TRASH | 5.40043 | 9.3758 | 4.57 | 21.2683 | Level 1 | Level 2 | 0 | 0 | Soiled Storage Room Space | 13-75 41 14 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C06 | 13-75 41 14: Soiled Storage Room Space | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2A14 | Level 2 | ADMIN | 32.8384 | 24.7893 | 4.68 | 147.783 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A14 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2CC2 | Level 2 | CORRIDOR | 13.3735 | 14.0406 | 4.68 | 59.2602 | Level 2 | Roof - Main | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2CC2 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B25 | Level 2 | SOIL. UTL. / TRASH | 7.46369 | 13.21 | 4.68 | 31.4753 | Level 2 | Roof - Main | 0 | 0 | Soiled Storage Room Space | 13-75 41 14 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B25 | 13-75 41 14: Soiled Storage Room Space | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E24 | Level 1 | RECEIVING / STORAGE | 118.296 | 47.1568 | 4.57 | 526.098 | Level 1 | Level 2 | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E24 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E10 | Level 1 | M. TOILET | 5.06216 | 9.206 | 4.57 | 20.3283 | Level 1 | Level 2 | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E10 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2AC4 | Level 2 | CORRIDOR | 14.3235 | 18.6571 | 4.68 | 62.7979 | Level 2 | Roof - Main | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2AC4 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B9 | Level 2 | TECH OFFICE | 9.94 | 12.68 | 4.68 | 42.9119 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B9 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1A06 | Level 1 | TRICARE OFFICE | 10.4921 | 13.0265 | 4.57 | 42.6276 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A06 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B17 | Level 1 | TECH. WORK ROOM | 24.0437 | 20.0581 | 4.57 | 105.278 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B17 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C05 | Level 2 | JAN. CL. | 3.69253 | 8.264 | 4.68 | 15.1496 | Level 2 | Roof - Main | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C05 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D03 | Level 1 | CLEAN U. | 2.35008 | 6.09322 | 4.57 | 9.54417 | Level 1 | Level 2 | 0 | 0 | Clean Room | 13-15 21 11 21 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D03 | 13-15 21 11 21: Clean Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1A16 | Level 1 | PHARM. DISP. | 67.5491 | 42.597 | 4.57 | 298.077 | Level 1 | Level 2 | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A16 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D18 | Level 2 | TECH. OFFICE | 84.8029 | 45.572 | 4.68 | 384.177 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D18 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1A08 | Level 1 | PHARM. OFFICE | 10.4499 | 12.989 | 4.57 | 43.4639 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A08 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B21 | Level 1 | COMM. ROOM | 9.80232 | 13.012 | 4.57 | 41.1801 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B21 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2BC5 | Level 2 | CORRIDOR | 22.7376 | 29.2148 | 4.68 | 98.007 | Level 2 | Roof - Main | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2BC5 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2A09 | Level 2 | GEN. DENT. DTR #5 | 11.3064 | 11.3499 | 4.68 | 49.0894 | Level 2 | Roof - Main | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A09 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B09 | Level 1 | DRESS | 4.64607 | 8.64805 | 4.57 | 18.8525 | Level 1 | Level 2 | 0 | 0 | Dressing Room | 13-41 11 41 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B09 | 13-41 11 41 11: Dressing Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B2 | Level 2 | JAN. CL. | 2.20008 | 5.938 | 4.68 | 8.8583 | Level 2 | Roof - Main | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B2 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1AC3 | Level 1 | CORRIDOR | 16.2935 | 21.4955 | 4.57 | 68.5881 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1AC3 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D28 | Level 1 | INTERACTION STATION | 12.6883 | 14.364 | 4.57 | 53.9857 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D28 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D10 | Level 2 | SEC. WAIT | 16.632 | 17.017 | 4.68 | 73.3064 | Level 2 | Roof - Main | 0 | 0 | Waiting Room | 13-51 31 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D10 | 13-51 31 11: Waiting Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
E1 | Level 1 | ELEVATOR | 4.35577 | 7.40728 | 9.25 | 36.4204 | Level 1 | Roof - Main | 0 | 0 | Elevator Shaft | 13-81 21 31 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | E1 | 13-81 21 31: Elevator Shaft | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2AC3 | Level 2 | CORRIDOR | 27.093 | 24.1223 | 4.68 | 121.78 | Level 2 | Roof - Main | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2AC3 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E02 | Level 1 | ELEV. EQUIP. | 5.67552 | 9.752 | 4.57 | 23.2443 | Level 1 | Level 2 | 0 | 0 | Equipment Room | 13-81 21 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E02 | 13-81 21 11: Equipment Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
3R04 | Roof - Main | ROOF | 15.2157 | 30.5471 | 5.2 | 77.9582 | Roof - Main | Roof - Main | 4 | -1.2 | Other General Facility Service Spaces | 13-81 11 99 | Circulation Zone 3R | Fire Alarm Zone 3R | Historic Preservation Zone 3R | Lighting Zone 3R | Occupancy Zone 3R | Ventilation Zone 3R | 3R04 | 13-81 11 99: Other General Facility Service Spaces | RoomTag
2A13 | Level 2 | DEVELOPING | 7.5623 | 11.778 | 4.68 | 32.2219 | Level 2 | Roof - Main | 0 | 0 | Scanning/Imaging Room | 13-41 41 31 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A13 | 13-41 41 31: Scanning/Imaging Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
3R01 | Roof - Main | ROOF | 1568.12 | 277.051 | 4 | 6257.34 | Roof - Main | Roof - Main | 4 | 0 | Other General Facility Service Spaces | 13-81 11 99 | Circulation Zone 3R | Fire Alarm Zone 3R | Historic Preservation Zone 3R | Lighting Zone 3R | Occupancy Zone 3R | Ventilation Zone 3R | 3R01 | 13-81 11 99: Other General Facility Service Spaces | RoomTag
1E09 | Level 1 | W. TOILET | 5.06216 | 9.206 | 4.57 | 20.3283 | Level 1 | Level 2 | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E09 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D16 | Level 1 | PROVIDER CUBICLES | 67.8336 | 36.731 | 4.57 | 300.685 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D16 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1EC1 | Level 1 | CORRIDOR | 54.6636 | 63.909 | 4.57 | 233.013 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1EC1 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2D05 | Level 2 | MAIN MECHANICAL ROOM | 231.114 | 65.482 | 4.68 | 1057.88 | Level 2 | Roof - Main | 0 | 0 | Mechanical Room | 13-81 21 17 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D05 | 13-81 21 17: Mechanical Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E12 | Level 1 | ISOLATION TOILET | 5.25186 | 9.282 | 4.57 | 21.2571 | Level 1 | Level 2 | 0 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E12 | 13-41 11 14 21: Restroom | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C11 | Level 2 | HK | 5.0922 | 8.57062 | 4.68 | 21.3982 | Level 2 | Roof - Main | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C11 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1BC3 | Level 1 | CORRIDOR | 13.4396 | 18.0333 | 4.57 | 56.7818 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1BC3 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B14 | Level 1 | SOIL. UTL. | 4.03581 | 8.609 | 4.57 | 15.6642 | Level 1 | Level 2 | 0 | 0 | Soiled Storage Room Space | 13-75 41 14 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B14 | 13-75 41 14: Soiled Storage Room Space | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E33 | Level 1 | ISOLATION INTERACTION STATION | 13.354 | 15.028 | 4.57 | 56.9228 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E33 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1A05 | Level 1 | TRICARE OFFICE | 8.99911 | 12.192 | 4.57 | 37.9204 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A05 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1CC2 | Level 1 | CORRIDOR | 8.23209 | 12.0636 | 4.57 | 34.5926 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1CC2 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2AC2 | Level 2 | CORRIDOR | 15.0174 | 21.167 | 4.68 | 65.173 | Level 2 | Roof - Main | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2AC2 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E17 | Level 1 | HAZ. STOR. | 9.78713 | 10.5993 | 4.57 | 39.5605 | Level 1 | Level 2 | 0 | 0 | Hazardous Material Storage Space | 13-75 41 24 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E17 | 13-75 41 24: Hazardous Material Storage Space | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1C09 | Level 1 | FUNDUS CAMERA ROOM | 14.9278 | 16.234 | 4.57 | 62.9373 | Level 1 | Level 2 | 0 | 0 | Scanning/Imaging Room | 13-41 41 31 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C09 | 13-41 41 31: Scanning/Imaging Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E30 | Level 1 | SOIL. LIN. | 6.87827 | 10.7732 | 4.57 | 28.3648 | Level 1 | Level 2 | 0 | 0 | Soiled Storage Room Space | 13-75 41 14 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E30 | 13-75 41 14: Soiled Storage Room Space | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1AC1 | Level 1 | CENTRAL WAITING | 139.755 | 69.8421 | 4.57 | 625.302 | Level 1 | Level 2 | 0 | 0 | Waiting Room | 13-51 31 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1AC1 | 13-51 31 11: Waiting Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C09 | Level 2 | GEN. DENT. DTR #9 | 11.3638 | 11.9485 | 4.68 | 48.9519 | Level 2 | Roof - Main | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C09 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2A03 | Level 2 | SEC. OFFICE | 16.0095 | 16.097 | 4.68 | 69.1645 | Level 2 | Roof - Main | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A03 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E14 | Level 1 | DISASTER STOR. | 22.3553 | 19.889 | 4.57 | 96.6154 | Level 1 | Level 2 | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E14 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1DC2 | Level 1 | CORRIDOR | 6.34736 | 10.67 | 4.57 | 27.117 | Level 1 | Level 2 | 0 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1DC2 | 13-85 11 11: Corridor | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B07 | Level 1 | DRESS | 4.42138 | 8.704 | 4.57 | 17.8098 | Level 1 | Level 2 | 0 | 0 | Dressing Room | 13-41 11 41 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B07 | 13-41 11 41 11: Dressing Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B15 | Level 1 | FILM VIEW | 5.83705 | 9.664 | 4.57 | 24.0074 | Level 1 | Level 2 | 0 | 0 | Scanning/Imaging Room | 13-41 41 31 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B15 | 13-41 41 31: Scanning/Imaging Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E21 | Level 1 | FLAMABLE STORAGE | 5.66451 | 9.75218 | 4.57 | 22.0609 | Level 1 | Level 2 | 0 | 0 | Hazardous Material Storage Space | 13-75 41 24 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E21 | 13-75 41 24: Hazardous Material Storage Space | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B03 | Level 1 | BLOOD DRAW | 9.68098 | 12.732 | 4.57 | 40.7049 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B03 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D38 | Level 1 | TRMT ROOM | 23.2605 | 19.59 | 4.57 | 101.447 | Level 1 | Level 2 | 0 | 0 | Treatment Room | 13-41 41 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D38 | 13-41 41 11: Treatment Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D25 | Level 1 | PROVIDER CUBICLES | 67.8191 | 36.627 | 4.57 | 297.963 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D25 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1E07 | Level 1 | CONF. LIBRARY | 11.6309 | 13.652 | 4.57 | 49.3552 | Level 1 | Level 2 | 0 | 0 | Conference Room | 13-11 21 17 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E07 | 13-11 21 17: Conference Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D07 | Level 1 | INTERACTION STATION | 12.5663 | 14.397 | 4.57 | 53.6586 | Level 1 | Level 2 | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D07 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
3R02 | Roof - Main | ROOF | 15.2233 | 30.5481 | 5.2 | 77.9977 | Roof - Main | Roof - Main | 4 | -1.2 | Other General Facility Service Spaces | 13-81 11 99 | Circulation Zone 3R | Fire Alarm Zone 3R | Historic Preservation Zone 3R | Lighting Zone 3R | Occupancy Zone 3R | Ventilation Zone 3R | 3R02 | 13-81 11 99: Other General Facility Service Spaces | RoomTag
1C03 | Level 1 | JAN. CL. | 4.1106 | 8.924 | 4.57 | 16.2089 | Level 1 | Level 2 | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C03 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B12 | Level 1 | CLEAN SUP. & EQUIP. | 3.90136 | 8.51705 | 4.57 | 15.0909 | Level 1 | Level 2 | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B12 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2C03 | Level 2 | CONSULT. | 33.4926 | 28.4362 | 4.68 | 149.465 | Level 2 | Roof - Main | 0 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C03 | 13-41 41 99: Other Healing Spaces | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D37 | Level 1 | CLEAN U. | 2.35008 | 6.09322 | 4.57 | 9.54417 | Level 1 | Level 2 | 0 | 0 | Clean Room | 13-15 21 11 21 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D37 | 13-15 21 11 21: Clean Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B16 | Level 1 | JAN. CL. | 4.03581 | 8.609 | 4.57 | 15.6642 | Level 1 | Level 2 | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B16 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1B10 | Level 1 | STAFF LOUNGE | 10.2834 | 13.649 | 4.57 | 42.9879 | Level 1 | Level 2 | 0 | 0 | Break Room | 13-51 11 21 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B10 | 13-51 11 21: Break Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
2B20 | Level 2 | JAN. CL. | 3.23618 | 7.53312 | 4.68 | 13.2284 | Level 2 | Roof - Main | 0 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B20 | 13-75 11 11: Storage Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1C11 | Level 1 | ELEC. CL. | 0.777824 | 4.44 | 4.57 | 2.4667 | Level 1 | Level 2 | 0 | 0 | Electrical Room | 13-81 21 21 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C11 | 13-81 21 21: Electrical Room | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1C13 | Level 1 | COMM. ROOM | 11.8973 | 14.159 | 4.57 | 50.5667 | Level 1 | Level 2 | 0 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C13 | 13-15 11 34 11: Office | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
1D12 | Level 1 | SPECIMEN COLL. LAB | 10.2108 | 13.1729 | 4.57 | 43.0838 | Level 1 | Level 2 | 0 | 0 | Laboratory | 13-15 11 24 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D12 | 13-15 11 24 11: Laboratory | RoomTag | Pset_SpaceCommon - CeilingCovering: CeilingCovering; WallCovering: WallCovering; FloorCovering: FloorCovering; PSet_Revit_Other - CeilingCovering: CeilingCovering; FloorCovering: FloorCovering; WallCovering: WallCovering; LoadCapacity: LoadCapacity
