Properties of the parts of a building model (IFC2X3), part 172 of 295

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068623
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068628
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1068628
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 0.471725 m
PSet_Revit_Identity Data - Mark: 5065
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: -0.677026 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 0.222295 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.6 m; Start Offset: -0.6 m; End Offset: -0.6 m; Slope: 0
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068654
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1068654
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 0.591725 m
PSet_Revit_Identity Data - Mark: 5066
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: 2.82297 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 0.278844 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.67 m; Start Offset: -1.67 m; End Offset: -1.67 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068689
In: Level 1
Type - ElementType: Pipe Types:Mechanical Pipe:1068689
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 3.33173 m
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: -0.515863 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 1.57004 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.515863 m; Start Offset: -0.515863 m; End Offset: 2.81586 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 5067
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068757
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1068757
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 5068
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 1.15173 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.67 m; Start Offset: -1.67 m; End Offset: -1.67 m; Slope: 0
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: 2.82297 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 0.542738 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068764
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1068764
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.67 m; Start Offset: -1.67 m; End Offset: -1.67 m; Slope: 0
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: 2.82297 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 1.19305 m2
PSet_Revit_Identity Data - Mark: 5069
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 2.53173 m
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068771
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1068771
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: 2.82297 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 0.0149501 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 0.031725 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.67 m; Start Offset: -1.67 m; End Offset: -1.67 m; Slope: 0
PSet_Revit_Identity Data - Mark: 5070
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068776
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1068776
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.8 m; Start Offset: 3.8 m; End Offset: 3.8 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 4.32544 m
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: 8.29297 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 2.03832 m2
PSet_Revit_Identity Data - Mark: 5071
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068885
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1068885
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.505417; Size: 150 mmø; Diameter: 0.492126; Length: 5.30173 m
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: 2.98414 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 3369.44; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 3; Area: 2.49838 m2
PSet_Revit_Identity Data - Mark: 5072
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.58586 m; Start Offset: -1.58586 m; End Offset: 3.71586 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068890
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1068890
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.8 m; Start Offset: 3.8 m; End Offset: 3.8 m; Slope: 0
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: 8.31887 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 2236.67; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 4; Area: 2.90737 m2
PSet_Revit_Identity Data - Mark: 5073
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 9.25445 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1068907
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1068907
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 0.609244 m
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: 8.31887 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 2236.67; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 4; Area: 0.1914 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 5074
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.8 m; Start Offset: 3.8 m; End Offset: 3.8 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1069022
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1069022
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: 4.66684 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 2236.67; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 1; Area: 1.14493 m2
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 3.64443 m
PSet_Revit_Identity Data - Mark: 5080
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 0.0968375 m; Start Offset: 0.0968375 m; End Offset: 3.74126 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1069027
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1069027
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: 8.31887 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 2236.67; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 1; Area: 0.416105 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.8 m; Start Offset: 3.8 m; End Offset: 3.8 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 1.3245 m
PSet_Revit_Identity Data - Mark: 5081
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1070236
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1070236
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 0.0381 m; Start Offset: 0.0381 m; End Offset: 0.0381 m; Slope: 0
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: 4.55697 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 2236.67; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 1; Area: 0.0341426 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 0.108679 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 5083
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1070245
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1070245
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: 4.55697 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 2236.67; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 1; Area: 0.0341426 m2
PSet_Revit_Identity Data - Mark: 5084
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 0.108679 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 0.0381 m; Start Offset: 0.0381 m; End Offset: 0.0381 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1070306
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1070306
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: 8.31887 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 2236.67; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 4; Area: 0.0979592 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 0.311814 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.8 m; Start Offset: 3.8 m; End Offset: 3.8 m; Slope: 0
PSet_Revit_Identity Data - Mark: 5086
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1070333
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1070333
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: 8.51887 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 2236.67; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 5; Area: 0.0871925 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 4 m; Start Offset: 4 m; End Offset: 4 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 0.277542 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 5088
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1070408
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1070408
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: 4.55697 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 2236.67; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 5; Area: 0.0898883 m2
PSet_Revit_Identity Data - Mark: 5089
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 0.286123 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 0.0381 m; Start Offset: 0.0381 m; End Offset: 0.0381 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1070435
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1070435
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 0.0381 m; Start Offset: 0.0381 m; End Offset: 0.0381 m; Slope: 0
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: 4.55697 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 2236.67; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 4; Area: 0.0427443 m2
PSet_Revit_Identity Data - Mark: 5090
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 0.136059 m
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1070443
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1070443
PSet_Revit_Mechanical - System Type: Hydronic Supply; System Name: Hydronic Supply 1; Insulation Thickness: 0; Invert Elevation: 4.66684 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 2236.67; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 4; Area: 1.14493 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.74126 m; Start Offset: 3.74126 m; End Offset: 0.0968375 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 3.64443 m
PSet_Revit_Identity Data - Mark: 5091
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Mechanical Pipe:1070460
In: Level 2
Type - ElementType: Pipe Types:Mechanical Pipe:1070460
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 0.0968375 m; Start Offset: 0.0968375 m; End Offset: 3.94126 m
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 3.84443 m
PSet_Revit_Mechanical - System Type: Hydronic Return; System Name: Hydronic Return 1; Insulation Thickness: 0; Invert Elevation: 4.66684 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 2236.67; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 5; Area: 1.20776 m2
PSet_Revit_Identity Data - Mark: 5092
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Mechanical - Roughness: 0.00015; Material: Carbon Steel; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Other - Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Storm:1073571
In: Level 2
Type - ElementType: Pipe Types:Storm:1073571
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 0.3 m; Start Offset: 0.3 m; End Offset: 0.3 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 5093
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.550417; Size: 150 mmø; Diameter: 0.492126; Length: 0.400461 m
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Default Sanitary (cskender); Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 4.78612 m; Section: 176; Area: 0.188713 m2
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Storm:1073599
In: Roof - Main
Type - ElementType: Pipe Types:Storm:1073599
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.550417; Size: 150 mmø; Diameter: 0.492126; Length: 0.839363 m
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Default Sanitary (cskender); Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 8.26112 m; Section: 45; Area: 0.39554 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 5094
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Roof - Main; Offset: -0.905 m; Start Offset: -0.905 m; End Offset: -0.905 m; Slope: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Storm:1073944
In: Level 2
Type - ElementType: Pipe Types:Storm:1073944
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 1.35693 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -0.444 m; Start Offset: -0.444 m; End Offset: -0.444 m; Slope: 0
PSet_Revit_Mechanical - System Type: Undefined; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 4.07487 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 40260; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 0; Area: 0.426293 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 5097
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Storm:1073950
In: Level 2
Type - ElementType: Pipe Types:Storm:1073950
PSet_Revit_Mechanical - System Type: Undefined; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 4.07487 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 40260; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 0; Area: 0.0663945 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -0.444 m; Start Offset: -0.444 m; End Offset: -0.444 m; Slope: 0
PSet_Revit_Identity Data - Mark: 5098
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 0.21134 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Storm:1073959
In: Level 2
Type - ElementType: Pipe Types:Storm:1073959
PSet_Revit_Identity Data - Mark: 5099
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -0.444 m; Start Offset: -0.444 m; End Offset: -0.444 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 2.37693 m
PSet_Revit_Mechanical - System Type: Undefined; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 4.07487 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 40260; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 0; Area: 0.746735 m2
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Storm:1074042
In: Level 2
Type - ElementType: Pipe Types:Storm:1074042
PSet_Revit_Mechanical - System Type: Undefined; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 4.18474 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 40260; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 0; Area: 0.121034 m2
PSet_Revit_Identity Data - Mark: 5101
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 0.385263 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -0.385263 m; Start Offset: -0.385263 m; End Offset: 0 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Storm:1074060
In: Level 2
Type - ElementType: Pipe Types:Storm:1074060
PSet_Revit_Identity Data - Mark: 5102
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 0.916409 m
PSet_Revit_Mechanical - System Type: Undefined; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 3.61387 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 40260; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 0; Area: 0.287898 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -0.905 m; Start Offset: -0.905 m; End Offset: -0.905 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Storm:1074122
In: Level 2
Type - ElementType: Pipe Types:Storm:1074122
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -0.846263 m; Start Offset: -0.846263 m; End Offset: 0 m
PSet_Revit_Mechanical - System Type: Undefined; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 3.72374 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 40260; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 0; Area: 0.265861 m2
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 0.846263 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 5104
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Storm:1074223
In: Level 1
Type - ElementType: Pipe Types:Storm:1074223
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 0.271727 m
PSet_Revit_Identity Data - Mark: 5105
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Undefined; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 0.24887 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 40260; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 0; Area: 0.0853656 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.3 m; Start Offset: 0.3 m; End Offset: 0.3 m; Slope: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Storm:1074230
In: Level 2
Type - ElementType: Pipe Types:Storm:1074230
PSet_Revit_Mechanical - System Type: Undefined; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 0.358737 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 40260; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 0; Area: 1.16507 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -0.502737 m; Start Offset: -0.502737 m; End Offset: -4.21126 m
PSet_Revit_Identity Data - Mark: 5106
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.375; Inner Diameter: 0.3355; Size: 100 mmø; Diameter: 0.328084; Length: 3.70853 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Storm:1074634
In: Level 2
Type - ElementType: Pipe Types:Storm:1074634
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.550417; Size: 150 mmø; Diameter: 0.492126; Length: 0.869323 m
PSet_Revit_Mechanical - System Type: Undefined; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 3.58112 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 66050; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 0; Area: 0.409659 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -0.905 m; Start Offset: -0.905 m; End Offset: -0.905 m; Slope: 0
PSet_Revit_Identity Data - Mark: 5110
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Storm:1074670
In: Level 2
Type - ElementType: Pipe Types:Storm:1074670
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.552083; Inner Diameter: 0.550417; Size: 150 mmø; Diameter: 0.492126; Length: 0.820863 m
PSet_Revit_Identity Data - Mark: 5112
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Undefined; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 3.74914 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 66050; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 0; Area: 0.386822 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -0.820863 m; Start Offset: -0.820863 m; End Offset: 0 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Storm:1074680
In: Level 2
Type - ElementType: Pipe Types:Storm:1074680
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Storm; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 3.88612 m; Section: 20; Area: 0.650786 m2
