Properties of the parts of a building model (IFC2X3), part 44 of 295

# IfcFlowFitting: Transition - Generic (1536)
Name (M_Transition - Generic:Transition - Generic:Transition - Generic:...) | In | Mark | System Type | System Name | Width Offset | Visibility 3 | Visibility 2 | Visibility 1 | Max Fitting Outside Diameter 12 | Height Offset | Fitting Outside Radius 2 = Insulation Radius 2 | Fitting Outside Radius 1 = Insulation Radius 1 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level | Host | Offset (m) | Tick Size 2 | Tick Size 1 | Nominal Radius 2 | Nominal Radius 1 | Nominal Diameter 2 | Nominal Diameter 1 | Length | Fitting Outside Diameter 2 | Fitting Outside Diameter 1 | Size | OffsetHeight | OffsetWidth
694546 | 1C13 | 6707 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1051406 | E1 | 12880 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.9582 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0653066 | 0.0656168
1070309 | 2D05 | 13717 | Hydronic Supply | Hydronic Supply 1 | 10 | no | yes | no | 0.510417 | 10 | 0.171875 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 3.8 | 0.1375 | 0.204167 | 0.164042 | 0.246063 | 0.328084 | 0.492126 | 0.127604 | 0.34375 | 0.510417 | 150 mmø-100 mmø | 0.246063 | 0.246063
1012881 | 1DC1 | 10611 | Fire Protection Wet | Fire Protection | 10.0027 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0682828
695422 | 1D02 | 6827 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
696964 | 1A11 | 6984 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1014097 | 1E26 | 11035 | Fire Protection Wet | Fire Protection | 9.99921 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0648315
1051613 | 2AC1 | 12936 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
694091 | 1C01 | 6664 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.046875 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0375 | 0.0875 | 0.0410105 | 0.106627 | 0.082021 | 0.213255 | 0.0546875 | 0.09375 | 0.21875 | 65 mmø-25 mmø | 0.106627 | 0.106627
641197 | TOF Footing | 2428 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
1078439 | TOF Footing | 14035 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
1080448 | TOF Footing | 14196 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
716019 | 1D16 | 9206 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
1013098 | 1DC1 | 10695 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0088 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0744117 | 0.0656168
1030318 | 2D05 | 11851 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
704351 | TOF Footing | 7883 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
634783 | TOF Footing | 1640 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.34375 | 10 | 0.130208 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.104167 | 0.1375 | 0.131234 | 0.164042 | 0.262467 | 0.328084 | 0.0859375 | 0.260417 | 0.34375 | 100 mmø-80 mmø | 0.164042 | 0.164042
1050100 | 2BC3 | 12516 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
717363 | 1C10 | 9337 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
699092 | 1C07 | 7275 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1052475 | 2A06 | 13134 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1026918 | 1BC3 | 11228 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0188 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0844583 | 0.0656168
709847 | TOF Footing | 8565 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.114583 | 10 | 0.0364583 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0458333 | 0.0328084 | 0.0524934 | 0.0656168 | 0.104987 | 0.0286458 | 0.0729167 | 0.114583 | 32 mmø-20 mmø | 0.0524934 | 0.0524934
640630 | TOF Footing | 2405 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
638353 | TOF Footing | 2127 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.501123 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
1077174 | 1D07 | 13921 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.135417 | 10 | 0.0677083 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.635088 | 0.0541667 | 0.0458333 | 0.0656168 | 0.0524934 | 0.131234 | 0.104987 | 0.0338542 | 0.135417 | 0.114583 | 40 mmø-32 mmø | 0.0524934 | 0.0524934
694246 | 1C15 | 6688 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
706541 | TOF Footing | 8105 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0260417 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.273012 | 0.0208333 | 0.0375 | 0.0246063 | 0.0410105 | 0.0492126 | 0.082021 | 0.0234375 | 0.0520833 | 0.09375 | 25 mmø-15 mmø | 0.0410105 | 0.0410105
708300 | TOF Footing | 8365 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1098064 | TOF Footing | 14890 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.382538 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
1004990 | 1E16 | 10348 | Fire Protection Wet | Fire Protection | 10.0057 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0713131
714479 | 1D10 | 9055 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0364583 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0291667 | 0.0541667 | 0.0328084 | 0.0656168 | 0.0656168 | 0.131234 | 0.0338542 | 0.0729167 | 0.135417 | 40 mmø-20 mmø | 0.0656168 | 0.0656168
689256 | TOF Footing | 6163 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.34375 | 10 | 0.046875 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0375 | 0.1375 | 0.0410105 | 0.164042 | 0.082021 | 0.328084 | 0.0859375 | 0.09375 | 0.34375 | 100 mmø-25 mmø | 0.164042 | 0.164042
708539 | TOF Footing | 8394 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.114583 | 10 | 0.0260417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0458333 | 0.0246063 | 0.0524934 | 0.0492126 | 0.104987 | 0.0286458 | 0.0520833 | 0.114583 | 32 mmø-15 mmø | 0.0524934 | 0.0524934
1012719 | 1DC1 | 10551 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
718881 | 1A11 | 9456 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0260417 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0375 | 0.0246063 | 0.0410105 | 0.0492126 | 0.082021 | 0.0234375 | 0.0520833 | 0.09375 | 25 mmø-15 mmø | 0.0410105 | 0.0410105
710387 | TOF Footing | 8610 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.114583 | 10 | 0.0260417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0458333 | 0.0246063 | 0.0524934 | 0.0492126 | 0.104987 | 0.0286458 | 0.0520833 | 0.114583 | 32 mmø-15 mmø | 0.0524934 | 0.0524934
1013650 | 1C19 | 10875 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
719364 | 1A05 | 9502 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.45 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
717860 | 1C07 | 9389 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.114583 | 10 | 0.046875 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0375 | 0.0458333 | 0.0410105 | 0.0524934 | 0.082021 | 0.104987 | 0.0286458 | 0.09375 | 0.114583 | 32 mmø-25 mmø | 0.0524934 | 0.0524934
703593 | TOF Footing | 7788 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.460312 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
705725 | TOF Footing | 8031 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.25 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1012955 | 1D22 | 10639 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1025937 | 1E04 | 11074 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
1012484 | 1E12 | 10503 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
682645 | TOF Footing | 5372 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1027209 | 1B09 | 11336 | Fire Protection Wet | Fire Protection | 9.99441 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0600259
1013302 | 1D16 | 10771 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.017 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0825816 | 0.0656168
717826 | 1C07 | 9388 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1002507 | 1AC2 | 10260 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
1027123 | 1B04 | 11308 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
641639 | TOF Footing | 2489 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.460312 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
1030385 | 2D05 | 11858 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
1027746 | 1AC5 | 11500 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0111 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0767131 | 0.0656168
1050946 | 2B01 | 12768 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1049644 | 2D18 | 12408 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1013790 | 1CC1 | 10911 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1052926 | 2D18 | 13254 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1082820 | 2A08 | 14385 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.2 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
633211 | TOF Footing | 1402 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.260417 | 10 | 0.0885417 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0708333 | 0.104167 | 0.082021 | 0.131234 | 0.164042 | 0.262467 | 0.0651042 | 0.177083 | 0.260417 | 80 mmø-50 mmø | 0.131234 | 0.131234
711465 | TOF Footing | 8755 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
709820 | TOF Footing | 8560 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.25 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
707324 | TOF Footing | 8215 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0364583 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0375 | 0.0328084 | 0.0410105 | 0.0656168 | 0.082021 | 0.0234375 | 0.0729167 | 0.09375 | 25 mmø-20 mmø | 0.0410105 | 0.0410105
684741 | TOF Footing | 5592 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1052942 | 2D18 | 13262 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 9.99757 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0631878 | 0.0656168
1030227 | 2D18 | 11843 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
715827 | Level 1 | 9185 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0260417 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0375 | 0.0246063 | 0.0410105 | 0.0492126 | 0.082021 | 0.0234375 | 0.0520833 | 0.09375 | 25 mmø-15 mmø | 0.0410105 | 0.0410105
1026683 | 1D35 | 11152 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1050119 | 2BC3 | 12524 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1082130 | 2C09 | 14317 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.2 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
1051308 | 2D04-A | 12848 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.98518 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
662268 | TOF Footing | 4186 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.460312 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
1080035 | TOF Footing | 14155 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
683690 | TOF Footing | 5463 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
1077596 | Level 1 | 13972 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0260417 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.2 | 0.0208333 | 0.0375 | 0.0246063 | 0.0410105 | 0.0492126 | 0.082021 | 0.0234375 | 0.0520833 | 0.09375 | 25 mmø-15 mmø | 0.0410105 | 0.0410105
1050205 | 2B18 | 12552 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
711694 | TOF Footing | 8774 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
715257 | 1D08 | 9115 | Domestic Hot Water | Domestic Hot Water 1 | 10 | yes | no | no | 0.21875 | 10 | 0.109375 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0875 | 0.0541667 | 0.106627 | 0.0656168 | 0.213255 | 0.131234 | 0.0546875 | 0.21875 | 0.135417 | 65 mmø-40 mmø | 0.0656168 | 0.0656168
719524 | 1A05 | 9528 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.45 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
636423 | TOF Footing | 1884 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.260417 | 10 | 0.0885417 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0708333 | 0.104167 | 0.082021 | 0.131234 | 0.164042 | 0.262467 | 0.0651042 | 0.177083 | 0.260417 | 80 mmø-50 mmø | 0.131234 | 0.131234
694547 | 1C13 | 6708 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
697173 | 1A05 | 7012 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
710206 | TOF Footing | 8588 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1077640 | 1D08 | 13980 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
1098422 | TOF Footing | 14935 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.260417 | 10 | 0.130208 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.326987 | 0.104167 | 0.0541667 | 0.131234 | 0.0656168 | 0.262467 | 0.131234 | 0.0651042 | 0.260417 | 0.135417 | 80 mmø-40 mmø | 0.0656168 | 0.0656168
1027981 | 1EC1 | 11580 | Fire Protection Wet | Fire Protection | 9.95695 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0225686
1026641 | 1D36 | 11144 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
707265 | TOF Footing | 8198 | Domestic Hot Water | Domestic Hot Water 1 | 10 | yes | no | no | 0.114583 | 10 | 0.0572917 | 0.0260417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0458333 | 0.0208333 | 0.0524934 | 0.0246063 | 0.104987 | 0.0492126 | 0.0286458 | 0.114583 | 0.0520833 | 32 mmø-15 mmø | 0.0246063 | 0.0246063
1049908 | 2D14 | 12468 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
658854 | Level 2 | 3758 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.9 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
1012911 | 1DC1 | 10627 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1026494 | 1BC4 | 11096 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1051268 | 2D04 | 12840 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
703685 | TOF Footing | 7801 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.35 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1013867 | 1C07 | 10943 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 9.99797 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0635852 | 0.0656168
698800 | 1D08 | 7208 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
707150 | TOF Footing | 8169 | Domestic Hot Water | Domestic Hot Water 1 | 10 | yes | no | no | 0.0729167 | 10 | 0.0364583 | 0.0260417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0208333 | 0.0328084 | 0.0246063 | 0.0656168 | 0.0492126 | 0.0182292 | 0.0729167 | 0.0520833 | 20 mmø-15 mmø | 0.0246063 | 0.0246063
1127269 | 1D20 | 15539 | Domestic Cold Water | Domestic Cold Water 1 | 10 | yes | no | no | 0.21875 | 10 | 0.109375 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.55 | 0.0875 | 0.0458333 | 0.106627 | 0.0524934 | 0.213255 | 0.104987 | 0.0546875 | 0.21875 | 0.114583 | 65 mmø-32 mmø | 0.0524934 | 0.0524934
694822 | 1C02 | 6739 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.0364583 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0291667 | 0.0875 | 0.0328084 | 0.106627 | 0.0656168 | 0.213255 | 0.0546875 | 0.0729167 | 0.21875 | 65 mmø-20 mmø | 0.106627 | 0.106627
717872 | 1C07 | 9393 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0364583 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0291667 | 0.0375 | 0.0328084 | 0.0410105 | 0.0656168 | 0.082021 | 0.0234375 | 0.0729167 | 0.09375 | 25 mmø-20 mmø | 0.0410105 | 0.0410105
1013391 | 1C18 | 10799 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1030994 | 2C13 | 11880 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
692951 | Level 2 | 6566 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.2 | 0.0375 | 0.0708333 | 0.0410105 | 0.082021 | 0.082021 | 0.164042 | 0.0442708 | 0.09375 | 0.177083 | 50 mmø-25 mmø | 0.082021 | 0.082021
708516 | TOF Footing | 8389 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
707436 | TOF Footing | 8239 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
689849 | TOF Footing | 6208 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.34375 | 10 | 0.046875 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0375 | 0.1375 | 0.0410105 | 0.164042 | 0.082021 | 0.328084 | 0.0859375 | 0.09375 | 0.34375 | 100 mmø-25 mmø | 0.164042 | 0.164042
705551 | TOF Footing | 8017 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.114583 | 10 | 0.0260417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0458333 | 0.0246063 | 0.0524934 | 0.0492126 | 0.104987 | 0.0286458 | 0.0520833 | 0.114583 | 32 mmø-15 mmø | 0.0524934 | 0.0524934
711670 | TOF Footing | 8771 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
635044 | TOF Footing | 1687 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.260417 | 10 | 0.0885417 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0708333 | 0.104167 | 0.082021 | 0.131234 | 0.164042 | 0.262467 | 0.0651042 | 0.177083 | 0.260417 | 80 mmø-50 mmø | 0.131234 | 0.131234
642089 | TOF Footing | 2554 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0677083 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.434912 | 0.0541667 | 0.1375 | 0.0656168 | 0.164042 | 0.131234 | 0.328084 | 0.0859375 | 0.135417 | 0.34375 | 100 mmø-40 mmø | 0.164042 | 0.164042
1030414 | 2D05 | 11860 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
716447 | 1C15 | 9241 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1049333 | 2D05 | 12328 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1026870 | 1BC4 | 11204 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 9.98959 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0552034 | 0.0656168
714002 | 1DC6 | 9025 | Domestic Hot Water | Domestic Hot Water 1 | 10 | yes | no | no | 0.135417 | 10 | 0.0677083 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 3.17 | 0.0541667 | 0.0458333 | 0.0656168 | 0.0524934 | 0.131234 | 0.104987 | 0.0338542 | 0.135417 | 0.114583 | 40 mmø-32 mmø | 0.0524934 | 0.0524934
1082350 | 2C04 | 14351 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.610319 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
716713 | Level 1 | 9263 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1012696 | 1D25 | 10547 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1077532 | 1D02 | 13957 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.135417 | 10 | 0.0677083 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.635088 | 0.0541667 | 0.0458333 | 0.0656168 | 0.0524934 | 0.131234 | 0.104987 | 0.0338542 | 0.135417 | 0.114583 | 40 mmø-32 mmø | 0.0524934 | 0.0524934
636886 | TOF Footing | 1958 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
710641 | Level 1 | 8641 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.894556 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
1086783 | Level 1 | 14737 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.873 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
711444 | TOF Footing | 8753 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1082438 | 2C02 | 14355 | Undefined | Sanitary 1 | 10.0013 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.610319 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.066914
710351 | TOF Footing | 8605 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
682824 | TOF Footing | 5400 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
695376 | 1C07 | 6812 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
707959 | TOF Footing | 8305 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0364583 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0375 | 0.0328084 | 0.0410105 | 0.0656168 | 0.082021 | 0.0234375 | 0.0729167 | 0.09375 | 25 mmø-20 mmø | 0.0410105 | 0.0410105
702908 | TOF Footing | 7703 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0364583 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0375 | 0.0328084 | 0.0410105 | 0.0656168 | 0.082021 | 0.0234375 | 0.0729167 | 0.09375 | 25 mmø-20 mmø | 0.0410105 | 0.0410105
1047792 | 2CC5 | 11964 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
713919 | Level 1 | 9009 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0364583 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0291667 | 0.0541667 | 0.0328084 | 0.0656168 | 0.0656168 | 0.131234 | 0.0338542 | 0.0729167 | 0.135417 | 40 mmø-20 mmø | 0.0656168 | 0.0656168
657995 | 1D27 | 3652 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.62311 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
1016675 | 1CC1 | 11047 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
1122532 | 2A09 | 15172 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
715804 | 1C15 | 9180 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0375 | 0.0708333 | 0.0410105 | 0.082021 | 0.082021 | 0.164042 | 0.0442708 | 0.09375 | 0.177083 | 50 mmø-25 mmø | 0.082021 | 0.082021
1053205 | 2A11 | 13354 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
717825 | 1C07 | 9387 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1026534 | 1E04 | 11104 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
704510 | TOF Footing | 7898 | Domestic Hot Water | Domestic Hot Water 1 | 10 | yes | no | no | 0.0729167 | 10 | 0.0364583 | 0.0260417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0208333 | 0.0328084 | 0.0246063 | 0.0656168 | 0.0492126 | 0.0182292 | 0.0729167 | 0.0520833 | 20 mmø-15 mmø | 0.0246063 | 0.0246063
1027267 | 1B05 | 11352 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1051014 | 2B5 | 12784 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
700030 | TOF Footing | 7376 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
694578 | 1C01 | 6712 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0260417 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0375 | 0.0246063 | 0.0410105 | 0.0492126 | 0.082021 | 0.0234375 | 0.0520833 | 0.09375 | 25 mmø-15 mmø | 0.0410105 | 0.0410105
639163 | TOF Footing | 2169 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.260417 | 10 | 0.130208 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.467786 | 0.104167 | 0.0708333 | 0.131234 | 0.082021 | 0.262467 | 0.164042 | 0.0651042 | 0.260417 | 0.177083 | 80 mmø-50 mmø | 0.082021 | 0.082021
1028234 | 1DC3 | 11616 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1026514 | 1E01 | 11100 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
702329 | TOF Footing | 7605 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
714300 | 1D10 | 9037 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.0885417 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0708333 | 0.0875 | 0.082021 | 0.106627 | 0.164042 | 0.213255 | 0.0546875 | 0.177083 | 0.21875 | 65 mmø-50 mmø | 0.106627 | 0.106627
1013821 | 1AC3 | 10927 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0087 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0742994 | 0.0656168
