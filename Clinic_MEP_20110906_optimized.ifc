Properties of the parts of a building model (IFC2X3), part 14 of 295

# IfcFlowFitting: 45 Degree (707)
Name | In | Length 2 | Length 1 | Mark | System Type | System Name | ASHRAE Table | Level | Host | Offset (m) | Size | OffsetHeight | OffsetWidth | Num8 | Num7 | Num6 | Num5 | Num4 | Num3 | Num2 | Num1 | PSet_Revit_Other, Delta 2 | PSet_Revit_Other, Delta 1 | WidthOffset | WidthDelta | Width2 = Lining Width 2 = Insulation Width 2 | Width1 = Lining Width 1 = Insulation Width 1 | MaxDelta = Length 01 = Computed Length | Lining Height 2 = Insulation Height 2 = Height2 | Lining Height 1 = Insulation Height 1 = Height1 | HeightOffset | HeightDelta | Half Width 2 | Half Width 1 | Half Height 2 | Half Height 1
M_Rectangular Transition - Angle:45 Degree:45 Degree:567938 | 1A05 | 0.0990081 | 0.198016 | 3645 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -0.860475 | 275x250-250x250 | 0.410105 | 0.451115 | 1 | 1 | 1 | 1 | 0.5 | 0.25 | 0.5 | 0.5 | 0 | 0 | 10 | 0.082021 | 0.82021 | 0.902231 | 0.0990081 | 0.82021 | 0.82021 | 10 | 0 | 0.410105 | 0.451115 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:569666 | 2B18 | 0.594049 | 0.198016 | 7550 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07048 | 350x300-200x300 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.656168 | 1.14829 | 0.594049 | 0.984252 | 0.984252 | 10 | 0 | 0.328084 | 0.574147 | 0.492126 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568615 | 1CC1 | 0.164042 | 0.164042 | 5471 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570273 | 2C02 | 0 | 0 | 8866 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-300ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 0; Num 7: 0; Num 6: 0; Num 10: 0; Num 1: 0; Length 8: 0; Length 7: 0; Length 6: 0; Length 5: 0; Length 4: 0; Half H0: 0.492126; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0; Delta 1: 0; W0: 0.984252; Radius: 0.492126; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.492126; Lining H0: 0.984252; Length01: 0.246063; Insulation W0: 0.984252; Insulation Radius: 0.492126; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.984252
M_Rectangular Transition - Angle:45 Degree:45 Degree:568558 | 1D24 | 0.594049 | 0.198016 | 5414 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.35893 | 300x300-150x350 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.574147 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569791 | 2D16 | 0.0990081 | 0.396032 | 7902 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Level 2 | Level : Level 2 | 3.60955 | 275x250-300x150 | 0.409941 | 0.451115 | 2 | 4 | 1.998 | 2.002 | 0.5 | 0.25 | 0.5 | 0.5 | 0.000164042 | 0 | 10 | 0.082021 | 0.984252 | 0.902231 | 0.396032 | 0.492126 | 0.82021 | 9.99984 | 0.328084 | 0.492126 | 0.451115 | 0.246063 | 0.410105
M_Round Transition - Angle:45 Degree:45 Degree:569180 | 2C17 | 0.164042 | 0.164042 | 6200 | Supply Air | Mechanical Supply Air 2 | SD4-1 | Roof - Main | Level : Roof - Main | -1.28 | 350ø-250ø | 0.574147 | 0.574147 | PSet_Revit_Other - Num 1: 1.9685; Num 5: 4.75239; Num 4: 1; Num 3: 3.93701; Num 2: 1.9685; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0478456; OffsetHeightTemp: 0.0478456; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.164042; R1: 0.410105; R0: 0.574147; Lining Radius 1: 0.410105; Lining Radius 0: 0.574147; Insulation Radius 1: 0.410105; Insulation Radius 0: 0.574147; HeightOffsetfromBase: 10; ComputedLength: 0.396032
M_Rectangular Transition - Angle:45 Degree:45 Degree:569143 | 2AC1 | 0.198016 | 0.990081 | 6134 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.42322 | 300x550-300x300 | 0.492126 | 0.492126 | 5 | 25 | 5 | 5 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.984252 | 0.984252 | 0.990081 | 1.80446 | 0.984252 | 10 | 0.82021 | 0.492126 | 0.492126 | 0.902231 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569154 | 2A10 | 0.198016 | 0.594049 | 6148 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.66893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568979 | 2C06 | 0.492126 | 0.198016 | 5616 | Return Air | Mechanical Return Air 2 |  | Roof - Main | Level : Roof - Main | -0.73 | 1150x500-1000x500 | 0.82021 | 1.64042 | 1 | 1 | 1 | 1 | 3 | 9 | -1.08287e-14 | 6 | 0 | 0.246063 | 9.75394 | 0.492126 | 3.28084 | 3.77297 | 0.492126 | 1.64042 | 1.64042 | 10 | 0 | 1.64042 | 1.88648 | 0.82021 | 0.82021
M_Rectangular Transition - Angle:45 Degree:45 Degree:569052 | 2AC5 | 0.594049 | 0.198016 | 5800 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-150x250 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569279 | 2C06 | 0.297024 | 0.396032 | 6460 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.1705 | 200x350-275x250 | 0.410105 | 0.451115 | 2 | 4 | 2 | 2 | 1.5 | 2.25 | 1.5 | 1.5 | 0 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.396032 | 1.14829 | 0.82021 | 10 | 0.328084 | 0.328084 | 0.451115 | 0.574147 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568717 | 1B06 | 0.082021 | 0.082021 | 5536 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular Transition - Angle:45 Degree:45 Degree:568989 | 2A06 | 0.198016 | 0.198016 | 5690 | Return Air | Mechanical Return Air 2 |  | Roof - Main | Level : Roof - Main | -0.73 | 400x200-400x150 | 0.328084 | 0.656168 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.31234 | 1.31234 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.656168 | 0.656168 | 0.246063 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:569974 | 2D13 | 0.198016 | 0.198016 | 8351 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.68 | 350x200-350x150 | 0.328084 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.574147 | 0.574147 | 0.246063 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:569937 | 2D19 | 0.198016 | 0.198016 | 8284 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.78 | 450x300-450x250 | 0.492126 | 0.738189 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.47638 | 1.47638 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.738189 | 0.738189 | 0.410105 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:569780 | 2D17 | 0 | 0 | 7875 | Supply Air | Mechanical Supply Air 2 | SD4-2 | Roof - Main | Level : Roof - Main | -1.07048 | 250x300-250ø | 0.492126 | 0.410105 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 0; Length 8: 0; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.410105; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0; W0: 0.82021; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.82021; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.82021; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0347222; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Round Transition - Angle:45 Degree:45 Degree:567912 | 1A03 | 0.246063 | 0.246063 | 3528 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 2 | Level : Level 2 | -0.87 | 450ø-300ø | 0.738189 | 0.738189 | PSet_Revit_Other - Num 1: 2.95276; Num 5: 7.12858; Num 4: 1; Num 3: 5.90551; Num 2: 2.95276; Length 3: 2.84217e-14; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0615157; OffsetHeightTemp: 0.0615157; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.246063; R1: 0.492126; R0: 0.738189; Lining Radius 1: 0.492126; Lining Radius 0: 0.738189; Insulation Radius 1: 0.492126; Insulation Radius 0: 0.738189; HeightOffsetfromBase: 10; ComputedLength: 0.594049
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567527 | 1B17 | 0.164042 | 0.164042 | 2318 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:569446 | 2A11 | 0.198016 | 0.198016 | 6891 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07048 | 350x300-350x250 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.574147 | 0.574147 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567230 | 1D23 | 0.198016 | 0.594049 | 1460 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.8 | 450x300-450x150 | 0.492126 | 0.738189 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.47638 | 1.47638 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.738189 | 0.738189 | 0.246063 | 0.492126
M_Round Transition - Angle:45 Degree:45 Degree:568272 | 1DC3 | 0.082021 | 0.082021 | 4798 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 2 | Level : Level 2 | -0.87 | 350ø-300ø | 0.574147 | 0.574147 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0478456; OffsetHeightTemp: 0.0478456; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.492126; R0: 0.574147; Lining Radius 1: 0.492126; Lining Radius 0: 0.574147; Insulation Radius 1: 0.492126; Insulation Radius 0: 0.574147; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular Transition - Angle:45 Degree:45 Degree:567236 | 1D22 | 0.594049 | 0.594049 | 1467 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.51893 | 300x300-150x450 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.47638 | 0.984252 | 10 | 0.492126 | 0.246063 | 0.492126 | 0.738189 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568697 | 1E24 | 0.082021 | 0.082021 | 5522 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:569751 | 2D18 | 0.246063 | 0.246063 | 7806 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570129 | 2B15 | 0.594049 | 0.198016 | 8626 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-150x350 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.574147 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:566974 | 1D16 | 0.594049 | 0.396032 | 953 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.64 | 450x200-300x300 | 0.492126 | 0.492126 | 2 | 4 | 2 | 2 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 1.47638 | 0.984252 | 0.594049 | 0.656168 | 0.984252 | 10 | 0.328084 | 0.738189 | 0.492126 | 0.328084 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567678 | 1E33 | 0.198016 | 0.198016 | 2809 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.29998 | 150x250-100x200 | 0.410105 | 0.246063 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.328084 | 0.492126 | 0.198016 | 0.656168 | 0.82021 | 10 | 0.164042 | 0.164042 | 0.246063 | 0.328084 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:568508 | 1D19 | 0.198016 | 0.594049 | 5347 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.88 | 300x300-250x150 | 0.246063 | 0.410105 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.984252 | 0.82021 | 0.594049 | 0.984252 | 0.492126 | 10 | 0.492126 | 0.492126 | 0.410105 | 0.492126 | 0.246063
M_Rectangular Transition - Angle:45 Degree:45 Degree:566732 | 1EC1 | 0.198016 | 0.198016 | 230 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.755 | 550x250-550x200 | 0.410105 | 0.902231 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.80446 | 1.80446 | 0.198016 | 0.656168 | 0.82021 | 10 | 0.164042 | 0.902231 | 0.902231 | 0.328084 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:567056 | 1D27 | 0.198016 | 0.594049 | 1092 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.35893 | 300x300-250x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 0.492126 | 0.246063 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567573 | 1B01 | 0.205052 | 0.205052 | 2405 | Supply Air | Mechanical Supply Air 1 | SD4-2 | Level 1 | Level : Level 1 | 3.79952 | 200ø-75x250 | 0.410105 | 0.123031 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 2.5; Length 8: 0.495041; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.410105; Num 5: 6.03553; Num 4: 1; Num 3: 5; Num 2: 2.5; Length 3: 0; Half W0: 0.123031; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.205052; W0: 0.246063; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.246063; Lining Radius: 0.328084; Lining H0: 0.82021; Length01: 0.495041; Insulation W0: 0.246063; Insulation Radius: 0.328084; Insulation H0: 0.82021; H0: 0.82021; OffsetWidthTemp: -0.0104167; OffsetHeightTemp: 0.0347222; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:569819 | 2D10 | 0.396032 | 0.198016 | 7957 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.27047 | 250x200-150x250 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.246063 | 0.410105 | 0.410105 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:568504 | 1DC1 | 0.198016 | 0.594049 | 5343 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.78 | 250x300-250x150 | 0.492126 | 0.410105 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.82021 | 0.82021 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 0.410105 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569797 | 2D18 | 0.0990081 | 0.198016 | 7912 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.27047 | 275x250-300x200 | 0.409941 | 0.451115 | 1 | 1 | 0.998 | 1.002 | 0.5 | 0.25 | 0.5 | 0.5 | 0.000164042 | 0 | 10 | 0.082021 | 0.984252 | 0.902231 | 0.198016 | 0.656168 | 0.82021 | 9.99984 | 0.164042 | 0.492126 | 0.451115 | 0.328084 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570226 | 2D05 | -3.17524e-14 | 3.17524e-14 | 8806 | Supply Air | Mechanical Supply Air 2 |  | Roof - Main | Level : Roof - Main | -1.08 | 750x750-750ø | 1.23031 | 1.23031 | PSet_Revit_Other - Num 9: 1; Num 8: 0; Num 7: -8.66294e-14; Num 6: 8.66294e-14; Num 10: 0; Num 1: 3.87125e-13; Length 8: 0; Length 7: 0; Length 6: -7.10543e-15; Length 5: 7.10543e-15; Length 4: 0; Half H0: 1.23031; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: -3.87125e-13; Length 3: 0; Half W0: 1.23031; PSet_Revit_Dimensions - Delta 2: 0; Delta 1: 0; W0: 2.46063; Radius: 1.23031; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 2.46063; Lining Radius: 1.23031; Lining H0: 2.46063; Length01: 0.615157; Insulation W0: 2.46063; Insulation Radius: 1.23031; Insulation H0: 2.46063; H0: 2.46063; OffsetWidthTemp: -0.104167; OffsetHeightTemp: 0.104167; Diameter: 2.46063
M_Rectangular Transition - Angle:45 Degree:45 Degree:568491 | 1A01 | 0.198016 | 0.198016 | 5317 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.08464 | 300x350-300x300 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.984252 | 0.984252 | 0.198016 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.492126 | 0.492126 | 0.574147 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568380 | 1E06 | 0.198016 | 0.198016 | 5125 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.27 | 150x250-100x200 | 0.410105 | 0.246063 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.328084 | 0.492126 | 0.198016 | 0.656168 | 0.82021 | 10 | 0.164042 | 0.164042 | 0.246063 | 0.328084 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:568374 | 1E06 | 0.0990081 | 0.198016 | 5104 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -0.770471 | 275x250-250x250 | 0.409941 | 0.451115 | 1 | 1 | 1 | 1 | 0.5 | 0.25 | 0.5 | 0.5 | 0.000164042 | 0 | 10 | 0.082021 | 0.82021 | 0.902231 | 0.0990081 | 0.82021 | 0.82021 | 9.99984 | 0 | 0.410105 | 0.451115 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:567411 | 1E27 | 0.297024 | 0.198016 | 2041 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.50955 | 275x250-200x300 | 0.410269 | 0.451115 | 1 | 1 | 0.998 | 1.002 | 1.5 | 2.25 | 1.5 | 1.5 | 0.000164042 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.297024 | 0.984252 | 0.82021 | 10.0002 | 0.164042 | 0.328084 | 0.451115 | 0.492126 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568159 | 1D16 | 0 | 0 | 4351 | Supply Air | Mechanical Supply Air 1 | SD4-2 | Level 2 | Level : Level 2 | -1.2605 | 200x250-200ø | 0.410105 | 0.328084 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 0; Length 8: 0; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.410105; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.328084; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0; W0: 0.656168; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.656168; Lining Radius: 0.328084; Lining H0: 0.82021; Length01: 0.198016; Insulation W0: 0.656168; Insulation Radius: 0.328084; Insulation H0: 0.82021; H0: 0.82021; OffsetWidthTemp: -0.0277778; OffsetHeightTemp: 0.0347222; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:566753 | 1DC1 | 0.198016 | 0.990081 | 294 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.93 | 650x600-650x350 | 0.984252 | 1.06627 | 5 | 25 | 5 | 5 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 2.13255 | 2.13255 | 0.990081 | 1.14829 | 1.9685 | 10 | 0.82021 | 1.06627 | 1.06627 | 0.574147 | 0.984252
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570377 | 2D17 | 0 | 0 | 8923 | Supply Air | Mechanical Supply Air 2 | SD4-2 | Level 2 | Level : Level 2 | 3.60952 | 250x300-250ø | 0.492126 | 0.410105 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 0; Length 8: 0; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.410105; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0; W0: 0.82021; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.82021; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.82021; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0347222; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular Transition - Angle:45 Degree:45 Degree:567626 | 1D28 | 0.396032 | 0.198016 | 2637 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.2905 | 250x250-150x250 | 0.410105 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.82021 | 0.82021 | 10 | 0 | 0.246063 | 0.410105 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:570203 | 2D18 | 0.198016 | 0.594049 | 8758 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.78 | 600x500-600x350 | 0.574147 | 0.984252 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.9685 | 1.9685 | 0.594049 | 1.64042 | 1.14829 | 10 | 0.492126 | 0.984252 | 0.984252 | 0.82021 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:568197 | 1DC1 | 0.396032 | 0.198016 | 4478 | Supply Air | Mechanical Supply Air 1 |  | Level 2 | Level : Level 2 | -1.36053 | 250x250-150x300 | 0.492126 | 0.246063 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.82021 | 0.492126 | 0.396032 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.410105 | 0.246063 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:566894 | Level 1 | 0.198016 | 1.1881 | 785 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.64 | 250x450-250x150 | 0.738189 | 0.410105 | 6 | 36 | 6 | 6 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.82021 | 0.82021 | 1.1881 | 0.492126 | 1.47638 | 10 | 0.984252 | 0.410105 | 0.410105 | 0.246063 | 0.738189
M_Rectangular Transition - Angle:45 Degree:45 Degree:569010 | 2C09 | 0.594049 | 0.594049 | 5722 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-450x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 1.47638 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.738189 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:566964 | 1D13 | 0.594049 | 0.198016 | 933 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.35893 | 300x300-150x250 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.410105 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570287 | 2A14 | 0.164042 | 0.164042 | 8874 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:570548 | 1D35 | 2.17818 | 0.594049 | 9251 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 2 | Level : Level 2 | -1.25094 | 800x300-250x150 | 0.246063 | 0.410105 | 3 | 9 | 3 | 3 | 11 | 121 | 11 | 11 | 0 | 0 | 10 | 1.80446 | 2.62467 | 0.82021 | 2.17818 | 0.984252 | 0.492126 | 10 | 0.492126 | 1.31234 | 0.410105 | 0.492126 | 0.246063
M_Rectangular Transition - Angle:45 Degree:45 Degree:568522 | 1DC1 | 1.38611 | 0.198016 | 5369 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.64 | 650x250-300x300 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 7 | 49 | 7 | 7 | 0 | 0 | 10 | 1.14829 | 2.13255 | 0.984252 | 1.38611 | 0.82021 | 0.984252 | 10 | 0.164042 | 1.06627 | 0.492126 | 0.410105 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570250 | 2C03 | 0.164042 | 0.164042 | 8854 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:568356 | 1C04 | 0.396032 | 0.198016 | 5037 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.21048 | 350x300-250x250 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.82021 | 1.14829 | 0.396032 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.410105 | 0.574147 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567054 | Level 1 | 0.198016 | 1.1881 | 1090 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.64 | 250x450-250x150 | 0.738189 | 0.410105 | 6 | 36 | 6 | 6 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.82021 | 0.82021 | 1.1881 | 0.492126 | 1.47638 | 10 | 0.984252 | 0.410105 | 0.410105 | 0.246063 | 0.738189
M_Rectangular Transition - Angle:45 Degree:45 Degree:567042 | Level 1 | 0.198016 | 1.1881 | 1078 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.64 | 350x450-350x150 | 0.738189 | 0.574147 | 6 | 36 | 6 | 6 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 1.1881 | 0.492126 | 1.47638 | 10 | 0.984252 | 0.574147 | 0.574147 | 0.246063 | 0.738189
M_Rectangular Transition - Angle:45 Degree:45 Degree:567224 | 1C14 | 0.198016 | 0.594049 | 1452 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.35893 | 300x300-250x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570670 | 1A01 | 3.76231 | 0.594049 | 431 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.454 | 1200x300-250x150 | 0.492126 | 1.9685 | 3 | 9 | 3 | 3 | 19 | 361 | 19 | 19 | 0 | 0 | 10 | 3.1168 | 0.82021 | 3.93701 | 3.76231 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 1.9685 | 0.246063 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567604 | 1D25 | -2.84217e-14 | 2.84217e-14 | 2596 | Supply Air | Mechanical Supply Air 1 | SD4-2 | Level 1 | Level : Level 1 | 3.2905 | 200x250-200ø | 0.410105 | 0.328084 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 3.46517e-13; Length 8: 0; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.410105; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: -3.46517e-13; Length 3: 0; Half W0: 0.328084; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0; W0: 0.656168; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.656168; Lining Radius: 0.328084; Lining H0: 0.82021; Length01: 0.198016; Insulation W0: 0.656168; Insulation Radius: 0.328084; Insulation H0: 0.82021; H0: 0.82021; OffsetWidthTemp: -0.0277778; OffsetHeightTemp: 0.0347222; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:569089 | 2A09 | 0.198016 | 0.198016 | 5957 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.73 | 750x450-750x400 | 0.738189 | 1.23031 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 2.46063 | 2.46063 | 0.198016 | 1.31234 | 1.47638 | 10 | 0.164042 | 1.23031 | 1.23031 | 0.656168 | 0.738189
M_Rectangular Transition - Angle:45 Degree:45 Degree:570045 | 2BC3 | 0.198016 | 0.198016 | 8496 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.68 | 350x200-350x150 | 0.328084 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.574147 | 0.574147 | 0.246063 | 0.328084
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568388 | 1E06 | 0.164042 | 0.164042 | 5135 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:568977 | 2CC4 | 0.164042 | 0.198016 | 5600 | Return Air | Mechanical Return Air 2 |  | Roof - Main | Level : Roof - Main | -0.73 | 1200x500-1150x500 | 0.82021 | 1.88648 | 1 | 1 | 1 | 1 | 1 | 1 | -1.19115e-13 | 2 | 0 | 0.082021 | 9.91798 | 0.164042 | 3.77297 | 3.93701 | 0.164042 | 1.64042 | 1.64042 | 10 | 0 | 1.88648 | 1.9685 | 0.82021 | 0.82021
M_Rectangular Transition - Angle:45 Degree:45 Degree:568230 | 1D16 | 0.0990081 | 0.198016 | 4598 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.26047 | 275x250-250x250 | 0.409941 | 0.451115 | 1 | 1 | 1 | 1 | 0.5 | 0.25 | 0.5 | 0.5 | 0.000164042 | 0 | 10 | 0.082021 | 0.82021 | 0.902231 | 0.0990081 | 0.82021 | 0.82021 | 9.99984 | 0 | 0.410105 | 0.451115 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:567968 | 1A02 | 0.198016 | 0.198016 | 3752 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -0.860475 | 350x300-300x250 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.984252 | 1.14829 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.492126 | 0.574147 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570140 | 2B14 | 0.198016 | 0.594049 | 8635 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568142 | 1C15 | 0.396032 | 0.198016 | 4314 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.26048 | 250x200-150x250 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.246063 | 0.410105 | 0.410105 | 0.328084
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567886 | 1EC1 | 0.246063 | 0.246063 | 3413 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568351 | 1D02 | 0.0990081 | 0.396032 | 5008 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 2 | Level : Level 2 | -0.840899 | 425x350-400x250 | 0.574147 | 0.697178 | 2 | 4 | 2 | 2 | 0.5 | 0.25 | 0.5 | 0.5 | 0 | 0 | 10 | 0.082021 | 1.31234 | 1.39436 | 0.396032 | 0.82021 | 1.14829 | 10 | 0.328084 | 0.656168 | 0.697178 | 0.410105 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:570153 | 2B3 | 0.396032 | 0.594049 | 8672 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-400x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 1.31234 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.656168 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568998 | 2C19 | 0.594049 | 0.198016 | 5703 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-150x350 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.574147 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567144 | 1E05 | 0.594049 | 0.198016 | 1302 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.01893 | 300x300-150x250 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569290 | 2C03 | 0.198016 | 0.198016 | 6500 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.0705 | 250x250-200x200 | 0.410105 | 0.410105 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.656168 | 0.82021 | 0.198016 | 0.656168 | 0.82021 | 10 | 0.164042 | 0.328084 | 0.410105 | 0.328084 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568681 | 1EC1 | 0.246063 | 0.246063 | 5512 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567125 | 1E24 | 0.792065 | 0.396032 | 1226 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.79 | 500x200-300x300 | 0.492126 | 0.492126 | 2 | 4 | 2 | 2 | 4 | 16 | 4 | 4 | 0 | 0 | 10 | 0.656168 | 1.64042 | 0.984252 | 0.792065 | 0.656168 | 0.984252 | 10 | 0.328084 | 0.82021 | 0.492126 | 0.328084 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567211 | 1C18 | 0.396032 | 0.594049 | 1444 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.35893 | 300x300-400x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 1.31234 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.656168 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567133 | 1EC1 | 0.198016 | 0.198016 | 1256 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.08964 | 300x300-250x350 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.198016 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.410105 | 0.492126 | 0.574147 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567775 | 1D36 | 0.198016 | 0.198016 | 3121 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.3096 | 200x250-150x250 | 0.410105 | 0.328084 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.492126 | 0.656168 | 0.198016 | 0.82021 | 0.82021 | 10 | 0 | 0.246063 | 0.328084 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:567672 | 1E14 | 0.198016 | 0.198016 | 2758 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.3 | 250x200-200x200 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.656168 | 0.82021 | 0.198016 | 0.656168 | 0.656168 | 10 | 0 | 0.328084 | 0.410105 | 0.328084 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:566742 | 1E14 | 0.198016 | 0.198016 | 259 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.755 | 200x250-200x200 | 0.410105 | 0.328084 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.656168 | 0.656168 | 0.198016 | 0.656168 | 0.82021 | 10 | 0.164042 | 0.328084 | 0.328084 | 0.328084 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:566851 | 1B04 | 0.198016 | 0.198016 | 695 | Return Air | Mechanical Return Air 1 |  | Level 1 | Level : Level 1 | 3.3 | 300x250-300x200 | 0.410105 | 0.492126 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.984252 | 0.984252 | 0.198016 | 0.656168 | 0.82021 | 10 | 0.164042 | 0.492126 | 0.492126 | 0.328084 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567877 | 1E22 | 0.246063 | 0.246063 | 3405 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570244 | 2C19 | 0.164042 | 0.164042 | 8851 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:570503 | 1D10 | 0.594049 | 0.198016 | 9167 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.50893 | 300x300-150x250 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.410105 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567756 | 1D35 | 0.164042 | 0.164042 | 3079 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:568473 | 1CC1 | 0.198016 | 0.792065 | 5287 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.93 | 350x350-350x150 | 0.574147 | 0.574147 | 4 | 16 | 4 | 4 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.792065 | 0.492126 | 1.14829 | 10 | 0.656168 | 0.574147 | 0.574147 | 0.246063 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:566801 | 1DC3 | 0.198016 | 0.198016 | 487 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -1.27 | 400x200-400x150 | 0.328084 | 0.656168 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.31234 | 1.31234 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.656168 | 0.656168 | 0.246063 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:569289 | 2C03 | 0.396032 | 0.198016 | 6480 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07048 | 350x300-250x250 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.82021 | 1.14829 | 0.396032 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.410105 | 0.574147 | 0.410105 | 0.492126
M_Round Transition - Angle:45 Degree:45 Degree:567827 | 1EC1 | 0.082021 | 0.082021 | 3242 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 1 | Level : Level 1 | 3.4 | 350ø-300ø | 0.574147 | 0.574147 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 7.10543e-15; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0478456; OffsetHeightTemp: 0.0478456; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.492126; R0: 0.574147; Lining Radius 1: 0.492126; Lining Radius 0: 0.574147; Insulation Radius 1: 0.492126; Insulation Radius 0: 0.574147; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular Transition - Angle:45 Degree:45 Degree:567394 | 1EC2 | 0.198016 | 0.198016 | 1927 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.5 | 300x300-250x250 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.410105 | 0.492126 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569815 | 2D11 | 0.495041 | 0.198016 | 7955 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.27047 | 275x250-150x300 | 0.409941 | 0.451115 | 1 | 1 | 0.998 | 1.002 | 2.5 | 6.25 | 2.5 | 2.5 | 0.000164042 | 0 | 10 | 0.410105 | 0.492126 | 0.902231 | 0.495041 | 0.984252 | 0.82021 | 9.99984 | 0.164042 | 0.246063 | 0.451115 | 0.492126 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:569968 | 2D15 | 0.198016 | 0.594049 | 8332 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570438 | 2D05 | 0.792065 | 2.37619 | 8964 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Roof - Main | Level : Roof - Main | -1.655 | 900x900-700x300 | 0.492126 | 1.14829 | 12 | 144 | 12 | 12 | 4 | 16 | 4 | 4 | 0 | 0 | 10 | 0.656168 | 2.95276 | 2.29659 | 2.37619 | 2.95276 | 0.984252 | 10 | 1.9685 | 1.47638 | 1.14829 | 1.47638 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567024 | Level 1 | 0.198016 | 1.1881 | 1054 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.64 | 250x450-250x150 | 0.738189 | 0.410105 | 6 | 36 | 6 | 6 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.82021 | 0.82021 | 1.1881 | 0.492126 | 1.47638 | 10 | 0.984252 | 0.410105 | 0.410105 | 0.246063 | 0.738189
M_Rectangular Transition - Angle:45 Degree:45 Degree:567159 | 1D08 | 0.198016 | 0.594049 | 1356 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.01893 | 300x300-250x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:566834 | 1DC1 | 0.198016 | 0.396032 | 599 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.78 | 250x250-250x150 | 0.410105 | 0.410105 | 2 | 4 | 2 | 2 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.82021 | 0.82021 | 0.396032 | 0.492126 | 0.82021 | 10 | 0.328084 | 0.410105 | 0.410105 | 0.246063 | 0.410105
M_Round Transition - Angle:45 Degree:45 Degree:568093 | 1C18 | 0.164042 | 0.164042 | 4164 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 2 | Level : Level 2 | -1.32 | 250ø-150ø | 0.410105 | 0.410105 | PSet_Revit_Other - Num 1: 1.9685; Num 5: 4.75239; Num 4: 1; Num 3: 3.93701; Num 2: 1.9685; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0341754; OffsetHeightTemp: 0.0341754; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.164042; R1: 0.246063; R0: 0.410105; Lining Radius 1: 0.246063; Lining Radius 0: 0.410105; Insulation Radius 1: 0.246063; Insulation Radius 0: 0.410105; HeightOffsetfromBase: 10; ComputedLength: 0.396032
M_Rectangular Transition - Angle:45 Degree:45 Degree:569642 | 2B19 | 0.198016 | 0.594049 | 7497 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 2 | Level : Level 2 | 3.32844 | 300x300-250x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:566812 | 1A16 | 0.792065 | 0.198016 | 554 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -1.325 | 400x200-200x200 | 0.328084 | 0.656168 | 1 | 1 | 1 | 1 | 4 | 16 | 4 | 4 | 0 | 0 | 10 | 0.656168 | 0.656168 | 1.31234 | 0.792065 | 0.656168 | 0.656168 | 10 | 0 | 0.328084 | 0.656168 | 0.328084 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:567084 | 1E04 | 0.198016 | 0.594049 | 1184 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.01893 | 300x300-250x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568075 | 1C09 | 0.297024 | 0.198016 | 4097 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.26047 | 275x250-200x300 | 0.409941 | 0.451115 | 1 | 1 | 0.998 | 1.002 | 1.5 | 2.25 | 1.5 | 1.5 | 0.000164042 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.297024 | 0.984252 | 0.82021 | 9.99984 | 0.164042 | 0.328084 | 0.451115 | 0.492126 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570264 | 2A11 | 0.164042 | 0.164042 | 8861 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Round Transition - Angle:45 Degree:45 Degree:569249 | 2CC1 | 0.164042 | 0.164042 | 6398 | Supply Air | Mechanical Supply Air 2 | SD4-1 | Roof - Main | Level : Roof - Main | -1.08 | 300ø-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 1: 1.9685; Num 5: 4.75239; Num 4: 1; Num 3: 3.93701; Num 2: 1.9685; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0410105; OffsetHeightTemp: 0.0410105; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.164042; R1: 0.328084; R0: 0.492126; Lining Radius 1: 0.328084; Lining Radius 0: 0.492126; Insulation Radius 1: 0.328084; Insulation Radius 0: 0.492126; HeightOffsetfromBase: 10; ComputedLength: 0.396032
M_Rectangular Transition - Angle:45 Degree:45 Degree:569097 | 2A14 | 0.594049 | 0.198016 | 6015 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.73 | 550x400-400x400 | 0.656168 | 0.902231 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 1.31234 | 1.80446 | 0.594049 | 1.31234 | 1.31234 | 10 | 0 | 0.656168 | 0.902231 | 0.656168 | 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:566914 | 1A06 | 0.198016 | 0.198016 | 823 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.93 | 600x250-600x200 | 0.328084 | 0.984252 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.9685 | 1.9685 | 0.198016 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.984252 | 0.984252 | 0.410105 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:567007 | 1B13 | 0.594049 | 0.594049 | 1020 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.01893 | 300x300-450x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 1.47638 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.738189 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570678 | 1AC5 | 0.198016 | 0.396032 | 463 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.70953 | 350x300-400x200 | 0.492126 | 0.574147 | 2 | 4 | 2 | 2 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.31234 | 1.14829 | 0.396032 | 0.656168 | 0.984252 | 10 | 0.328084 | 0.656168 | 0.574147 | 0.328084 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570252 | 2C07 | 0.164042 | 0.164042 | 8855 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:569035 | 2A08 | 0.396032 | 0.594049 | 5756 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-400x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 1.31234 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.656168 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567754 | 1DC7 | 0.396032 | 0.198016 | 3077 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.30953 | 250x200-150x250 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.246063 | 0.410105 | 0.410105 | 0.328084
M_Round Transition - Angle:45 Degree:45 Degree:567916 | 1AC5 | 0.164042 | 0.164042 | 3573 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 2 | Level : Level 2 | -0.87 | 300ø-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 1: 1.9685; Num 5: 4.75239; Num 4: 1; Num 3: 3.93701; Num 2: 1.9685; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0410105; OffsetHeightTemp: 0.0410105; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.164042; R1: 0.328084; R0: 0.492126; Lining Radius 1: 0.328084; Lining Radius 0: 0.492126; Insulation Radius 1: 0.328084; Insulation Radius 0: 0.492126; HeightOffsetfromBase: 10; ComputedLength: 0.396032
M_Rectangular Transition - Angle:45 Degree:45 Degree:570148 | 2B9 | 0.198016 | 0.198016 | 8669 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.68 | 400x250-400x200 | 0.410105 | 0.656168 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.31234 | 1.31234 | 0.198016 | 0.656168 | 0.82021 | 10 | 0.164042 | 0.656168 | 0.656168 | 0.328084 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:570077 | 2BC4 | 0.198016 | 0.198016 | 8541 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.68 | 350x350-350x300 | 0.574147 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.198016 | 0.984252 | 1.14829 | 10 | 0.164042 | 0.574147 | 0.574147 | 0.492126 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:569698 | 2D04-A | 0.594049 | 0.198016 | 7662 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07051 | 350x350-200x350 | 0.574147 | 0.574147 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.656168 | 1.14829 | 0.594049 | 1.14829 | 1.14829 | 10 | 0 | 0.328084 | 0.574147 | 0.574147 | 0.574147
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568171 | 1C01 | 0 | 0 | 4404 | Supply Air | Mechanical Supply Air 1 | SD4-2 | Level 2 | Level : Level 2 | -1.27 | 200x250-200ø | 0.410105 | 0.328084 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 0; Length 8: 0; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.410105; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.328084; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0; W0: 0.656168; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.656168; Lining Radius: 0.328084; Lining H0: 0.82021; Length01: 0.198016; Insulation W0: 0.656168; Insulation Radius: 0.328084; Insulation H0: 0.82021; H0: 0.82021; OffsetWidthTemp: -0.0277778; OffsetHeightTemp: 0.0347222; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:566760 | 1DC1 | 0.198016 | 0.792065 | 344 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.93 | 350x350-350x150 | 0.574147 | 0.574147 | 4 | 16 | 4 | 4 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.792065 | 0.492126 | 1.14829 | 10 | 0.656168 | 0.574147 | 0.574147 | 0.246063 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:569297 | 2CC1 | 0.396032 | 0.198016 | 6523 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07048 | 350x300-250x250 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.82021 | 1.14829 | 0.396032 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.410105 | 0.574147 | 0.410105 | 0.492126
