Properties of the parts of a building model (IFC2X3), part 36 of 295

# IfcFlowFitting: Tee - Generic (921)
Name (M_Tee - Generic:Tee - Generic:Tee - Generic:...) | In | Center to End Label | Fitting Outside Radius = Insulation Radius | Angle 1 (deg) | Tick Size | Nominal Radius | Nominal Diameter | Fitting Outside Diameter | Center to End | Angle (deg) | Size | System Type | System Name | Mark | Level | Host | Offset (m)
1012836 | 1D27 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10588 | Level 1 | Level : Level 1 | 2.985
1013467 | 1CC3 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10824 | Level 1 | Level : Level 1 | 2.985
1086781 | Level 1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 14736 | Level 1 | Level : Level 1 | 0.873
717381 | Level 1 | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9338 | Level 2 | Level : Level 2 | -1.4
1047932 | 2CC3 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11993 | Level 2 | Level : Level 2 | 2.985
1002794 | 1A15 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10288 | Level 1 | Level : Level 1 | 2.985
1050481 | 2B14 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12629 | Level 2 | Level : Level 2 | 2.985
1047743 | 2C09 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11949 | Level 2 | Level : Level 2 | 2.985
635269 | TOF Footing | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Default Sanitary (cskender) | 1737 | Level 1 | Level : Level 1 | -0.3
1008342 | 1DC1 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10479 | Level 1 | Level : Level 1 | 2.985
1050732 | 2DC1 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12701 | Level 2 | Level : Level 2 | 2.98499
642608 | 1E12 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2616 | Level 1 | Level : Level 1 | 3.1
1127396 | 1D13 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 15544 | Level 2 | Level : Level 2 | -1.6882
682533 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5353 | Level 1 | Level : Level 1 | -0.4
710240 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8589 | Level 1 | Level : Level 1 | -0.3
707126 | TOF Footing | 0.0677083 | 0.0260417 | 90 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0520833 | 0.0677083 | 90 | 15 mmø-15 mmø-15 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8167 | Level 1 | Level : Level 1 | -0.3
1025276 | 1E15 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 11066 | Level 1 | Level : Level 1 | 2.985
696412 | 1AC3 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6924 | Level 2 | Level : Level 2 | -1.5
1052170 | 2AC5 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13057 | Level 2 | Level : Level 2 | 2.985
1109893 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 15020 | Level 2 | Level : Level 2 | 0.2
1028489 | 1DC3 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11629 | Level 1 | Level : Level 1 | 2.985
1013574 | 1C12 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10852 | Level 1 | Level : Level 1 | 2.985
1013547 | 1CC3 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10844 | Level 1 | Level : Level 1 | 2.985
704528 | TOF Footing | 0.0677083 | 0.0260417 | 90 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0520833 | 0.0677083 | 90 | 15 mmø-15 mmø-15 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7899 | Level 1 | Level : Level 1 | -0.3
1005101 | 1EC4 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10394 | Level 1 | Level : Level 1 | 2.985
1049723 | 2D18 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12421 | Level 2 | Level : Level 2 | 2.985
706537 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8102 | Level 1 | Level : Level 1 | -0.3
709843 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8562 | Level 1 | Level : Level 1 | -0.3
1053201 | 2A11 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13351 | Level 2 | Level : Level 2 | 2.985
635866 | TOF Footing | 0.109375 | 0.0677083 | 88.635 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 91.365 | 40 mmø-40 mmø-40 mmø | Sanitary | Default Sanitary (cskender) | 1817 | Level 1 | Level : Level 1 | -0.2
697993 | 1D10 | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7112 | Level 2 | Level : Level 2 | -1.5
1052674 | 2AC3 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13179 | Level 2 | Level : Level 2 | 2.985
1049573 | 2D18 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12389 | Level 2 | Level : Level 2 | 2.985
1051264 | 2D04 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12837 | Level 2 | Level : Level 2 | 2.985
1005069 | 1E21 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10378 | Level 1 | Level : Level 1 | 2.985
1050254 | 2BC3 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12565 | Level 2 | Level : Level 2 | 2.985
685956 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5745 | Level 1 | Level : Level 1 | -0.4
1052471 | 2A06 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13131 | Level 2 | Level : Level 2 | 2.985
1050115 | 2BC3 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12521 | Level 2 | Level : Level 2 | 2.985
1026601 | 1E06 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11129 | Level 1 | Level : Level 1 | 2.985
1001482 | 1E02 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10154 | Level 1 | Level : Level 1 | 2.985
1051010 | 2B5 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12781 | Level 2 | Level : Level 2 | 2.985
699458 | 1D16 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7307 | Level 2 | Level : Level 2 | -1.5
696082 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6870 | Level 2 | Level : Level 2 | 0.2
1113326 | 1DC5 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 15070 | Level 1 | Level : Level 1 | 2.985
1027961 | 1EC1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11569 | Level 1 | Level : Level 1 | 2.985
1053032 | 2BC5 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13299 | Level 2 | Level : Level 2 | 2.985
703631 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7795 | Level 1 | Level : Level 1 | -0.3
655526 | 1B05 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 3458 | Level 2 | Level : Level 2 | -0.2
634095 | 1B05 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Default Sanitary (cskender) | 1504 | Level 1 | Level : Level 1 | 2.9
702904 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7700 | Level 1 | Level : Level 1 | -0.3
1051320 | 2D04 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12853 | Level 2 | Level : Level 2 | 2.98518
635117 | TOF Footing | 0.314351 | 0.130208 | 45 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 45 | 80 mmø-80 mmø-80 mmø | Sanitary | Default Sanitary (cskender) | 1707 | Level 1 | Level : Level 1 | -0.5
697025 | 1A16 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6990 | Level 2 | Level : Level 2 | -1.5
686120 | Level 1 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5771 | Level 1 | Level : Level 1 | 0.688244
1012672 | 1D25 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10540 | Level 1 | Level : Level 1 | 2.985
1051182 | 2BC1 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12821 | Level 2 | Level : Level 2 | 2.985
1070305 | 2D05 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Hydronic Supply | Hydronic Supply 1 | 13714 | Level 2 | Level : Level 2 | 3.8
641261 | TOF Footing | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 2447 | Level 1 | Level : Level 1 | -0.5
634488 | TOF Footing | 0.410102 | 0.171875 | 45.4775 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 134.523 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 1589 | Level 1 | Level : Level 1 | -0.5
1005053 | 1E18 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10370 | Level 1 | Level : Level 1 | 2.985
639340 | TOF Footing | 0.214271 | 0.0885417 | 44.9031 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 44.9031 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2200 | Level 1 | Level : Level 1 | -0.501123
658582 | 1D13 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3720 | Level 2 | Level : Level 2 | -1.6882
635819 | TOF Footing | 0.327024 | 0.171875 | 55.4504 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 55.4504 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 1805 | Level 1 | Level : Level 1 | -0.5
1050281 | 2BC3 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12573 | Level 2 | Level : Level 2 | 2.985
695620 | Level 1 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6840 | Level 2 | Level : Level 2 | -1.5
1013626 | 1C16 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10868 | Level 1 | Level : Level 1 | 2.985
639014 | TOF Footing | 0.159415 | 0.0885417 | 58.0969 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 121.903 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2147 | Level 1 | Level : Level 1 | -0.501123
1025257 | 1EC1 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 11062 | Level 1 | Level : Level 1 | 2.985
1013039 | 1DC1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10672 | Level 1 | Level : Level 1 | 2.985
639647 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2243 | Level 1 | Level : Level 1 | -0.501123
1002912 | 1A05 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10296 | Level 1 | Level : Level 1 | 2.985
1012779 | 1D31 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10568 | Level 1 | Level : Level 1 | 2.985
702654 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7666 | Level 1 | Level : Level 1 | -0.3
706165 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8072 | Level 1 | Level : Level 1 | -0.3
702819 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7694 | Level 1 | Level : Level 1 | -0.3
1008008 | 1AC3 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10445 | Level 1 | Level : Level 1 | 2.985
643626 | TOF Footing | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 2756 | Level 1 | Level : Level 1 | -0.3
1052878 | 2A01 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13239 | Level 2 | Level : Level 2 | 2.985
700131 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7379 | Level 1 | Level : Level 1 | -0.3
641599 | TOF Footing | 0.314351 | 0.130208 | 45 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 45 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 2475 | Level 1 | Level : Level 1 | -0.5
709715 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8535 | Level 1 | Level : Level 1 | -0.25
1080342 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Default Sanitary (cskender) | 14179 | Level 1 | Level : Level 1 | -0.5
1012907 | 1DC1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10624 | Level 1 | Level : Level 1 | 2.985
1002355 | 1DC4 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10240 | Level 1 | Level : Level 1 | 2.985
689845 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6205 | Level 1 | Level : Level 1 | -0.4
642108 | TOF Footing | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 2557 | Level 1 | Level : Level 1 | -0.3
1002342 | 1DC1 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10236 | Level 1 | Level : Level 1 | 2.985
692580 | 1B03 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6519 | Level 2 | Level : Level 2 | -1.5
1052968 | 2D21 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13275 | Level 2 | Level : Level 2 | 2.985
647519 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3201 | Level 1 | Level : Level 1 | -0.5
636772 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1938 | Level 1 | Level : Level 1 | -0.5
706614 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8111 | Level 1 | Level : Level 1 | -0.3
640626 | TOF Footing | 0.413999 | 0.171875 | 45.0924 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 134.908 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2402 | Level 1 | Level : Level 1 | -0.5
643206 | TOF Footing | 0.213758 | 0.0885417 | 45 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 45 | 50 mmø-50 mmø-50 mmø | Sanitary | Default Sanitary (cskender) | 2697 | Level 1 | Level : Level 1 | -0.5
1080187 | TOF Footing | 0.321008 | 0.130208 | 44.1573 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 44.1573 | 80 mmø-80 mmø-80 mmø | Sanitary | Default Sanitary (cskender) | 14166 | Level 1 | Level : Level 1 | -0.5
639860 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2284 | Level 1 | Level : Level 1 | -0.501123
1014027 | 1E33 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11008 | Level 1 | Level : Level 1 | 2.985
696622 | 1AC3 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6936 | Level 2 | Level : Level 2 | -1.5
708406 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8372 | Level 1 | Level : Level 1 | -0.3
1050904 | 2BC4 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12757 | Level 2 | Level : Level 2 | 2.985
1079221 | Level 1 | 0.0677083 | 0.0260417 | 90 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0520833 | 0.0677083 | 90 | 15 mmø-15 mmø-15 mmø | Domestic Hot Water | Domestic Hot Water 1 | 14101 | Level 1 | Level : Level 1 | 0.3
1013964 | 1D09 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10976 | Level 1 | Level : Level 1 | 2.985
698400 | 1D01 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 7149 | Level 2 | Level : Level 2 | -1.56
1051642 | 2C23 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12941 | Level 2 | Level : Level 2 | 2.985
707850 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8283 | Level 1 | Level : Level 1 | -0.3
1096352 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 14858 | Level 1 | Level : Level 1 | -0.5
639405 | TOF Footing | 0.313434 | 0.171875 | 57.4773 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 57.4773 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2207 | Level 1 | Level : Level 1 | -0.501123
1052606 | 2AC3 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13163 | Level 2 | Level : Level 2 | 2.985
704143 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7853 | Level 1 | Level : Level 1 | -0.3
1029808 | 2BC2 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 11788 | Level 2 | Level : Level 2 | 2.98519
1002925 | 1A10 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10297 | Level 1 | Level : Level 1 | 2.985
641642 | TOF Footing | 0.163462 | 0.0677083 | 45 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 135 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 2492 | Level 1 | Level : Level 1 | -0.3
1027977 | 1EC1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11577 | Level 1 | Level : Level 1 | 2.985
712758 | 1B03 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8871 | Level 2 | Level : Level 2 | -1.4
641977 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2522 | Level 1 | Level : Level 1 | -0.5
640083 | TOF Footing | 0.325728 | 0.171875 | 55.638 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 124.362 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2326 | Level 1 | Level : Level 1 | -0.5
1013602 | 1C14 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10860 | Level 1 | Level : Level 1 | 2.985
1013008 | 1DC1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10656 | Level 1 | Level : Level 1 | 2.985
1026898 | 1BC3 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11217 | Level 1 | Level : Level 1 | 2.985
1012851 | 1DC5 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10596 | Level 1 | Level : Level 1 | 2.985
636666 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 1918 | Level 1 | Level : Level 1 | -0.5
1086766 | TOF Footing | 0.32325 | 0.171875 | 56 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 56 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 14730 | Level 1 | Level : Level 1 | -0.5
716277 | 1D16 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9222 | Level 2 | Level : Level 2 | -1.4
1051090 | 2B8 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12797 | Level 2 | Level : Level 2 | 2.985
641268 | TOF Footing | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 2453 | Level 1 | Level : Level 1 | -0.3
696763 | 1A12 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6951 | Level 2 | Level : Level 2 | -1.5
715266 | 1D10 | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9116 | Level 2 | Level : Level 2 | -1.4
1049186 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12269 | Level 2 | Level : Level 2 | 2.985
1081554 | 1C15 | 0.0677083 | 0.0260417 | 90 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0520833 | 0.0677083 | 90 | 15 mmø-15 mmø-15 mmø | Domestic Hot Water | Domestic Hot Water 1 | 14298 | Level 2 | Level : Level 2 | -1.4
699604 | 1D16 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7336 | Level 2 | Level : Level 2 | -1.5
1012764 | 1D30 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10560 | Level 1 | Level : Level 1 | 2.985
640679 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2409 | Level 1 | Level : Level 1 | -0.5
707588 | TOF Footing | 0.0677083 | 0.0260417 | 90 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0520833 | 0.0677083 | 90 | 15 mmø-15 mmø-15 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8259 | Level 1 | Level : Level 1 | -0.3
1079115 | 1D34 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 14075 | Level 1 | Level : Level 1 | 0.543338
716000 | 1C15 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9197 | Level 2 | Level : Level 2 | -1.4
701564 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7526 | Level 1 | Level : Level 1 | -0.3
702612 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7654 | Level 1 | Level : Level 1 | -0.4
693006 | 1B04 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6585 | Level 2 | Level : Level 2 | -1.5
1086088 | Level 2 | 0.0677083 | 0.0260417 | 90 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0520833 | 0.0677083 | 90 | 15 mmø-15 mmø-15 mmø | Domestic Cold Water | Domestic Cold Water 1 | 14678 | Level 2 | Level : Level 2 | 0.5
1053240 | 2A12 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13359 | Level 2 | Level : Level 2 | 2.985
1084470 | 1C02 | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 14557 | Level 2 | Level : Level 2 | -1.5
634374 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 1558 | Level 1 | Level : Level 1 | -0.5
643712 | TOF Footing | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 2768 | Level 1 | Level : Level 1 | -0.3
1029820 | 2BC3 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11792 | Level 2 | Level : Level 2 | 2.985
707432 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 8236 | Level 1 | Level : Level 1 | -0.4
1002871 | 1AC3 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10291 | Level 1 | Level : Level 1 | 2.985
1013979 | 1D13 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10984 | Level 1 | Level : Level 1 | 2.985
1016365 | 1DC4 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 11040 | Level 1 | Level : Level 1 | 2.985
1014011 | 1EC3 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11000 | Level 1 | Level : Level 1 | 2.985
635699 | TOF Footing | 0.401659 | 0.171875 | 46.3334 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 133.667 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 1791 | Level 1 | Level : Level 1 | -0.5
1049640 | 2D18 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12405 | Level 2 | Level : Level 2 | 2.985
713188 | 1B04 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8910 | Level 2 | Level : Level 2 | -1.43
1026695 | 1DC7 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11157 | Level 1 | Level : Level 1 | 2.985
1052331 | 2AC2 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 13088 | Level 2 | Level : Level 2 | 2.985
635853 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Default Sanitary (cskender) | 1811 | Level 1 | Level : Level 1 | -0.5
637425 | TOF Footing | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 2012 | Level 1 | Level : Level 1 | -0.501123
1013730 | 1C08 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10896 | Level 1 | Level : Level 1 | 2.985
1131731 | 1DC4 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 15638 | Level 1 | Level : Level 1 | 2.985
1026866 | 1BC4 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11201 | Level 1 | Level : Level 1 | 2.985
641362 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2458 | Level 2 | Level : Level 2 | -5.07
635228 | TOF Footing | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Default Sanitary (cskender) | 1731 | Level 1 | Level : Level 1 | -0.3
694574 | 1C01 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6709 | Level 2 | Level : Level 2 | -1.5
710964 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8665 | Level 1 | Level : Level 1 | -0.3
1002430 | 1DC4 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10245 | Level 1 | Level : Level 1 | 2.985
636557 | TOF Footing | 0.314351 | 0.130208 | 45 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 135 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 1903 | Level 1 | Level : Level 1 | -0.5
713039 | 1B04 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8899 | Level 2 | Level : Level 2 | -1.43
715549 | 1D10 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9145 | Level 2 | Level : Level 2 | -1.35
713914 | Level 1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9006 | Level 2 | Level : Level 2 | -1.4
714003 | 1DC6 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9026 | Level 2 | Level : Level 2 | -1.4
639808 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2273 | Level 1 | Level : Level 1 | -0.501123
634779 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 1637 | Level 1 | Level : Level 1 | -0.5
714846 | 1DC3 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9087 | Level 2 | Level : Level 2 | -1.4
717254 | 1C10 | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9324 | Level 2 | Level : Level 2 | -1.4
707743 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8264 | Level 1 | Level : Level 1 | -0.3
1062826 | 1CC1 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 13505 | Level 1 | Level : Level 1 | 2.985
635998 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1839 | Level 1 | Level : Level 1 | -0.3
1083161 | Level 1 | 0.0677083 | 0.0260417 | 90 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0520833 | 0.0677083 | 90 | 15 mmø-15 mmø-15 mmø | Domestic Hot Water | Domestic Hot Water 1 | 14428 | Level 2 | Level : Level 2 | -1.45
1049347 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12333 | Level 2 | Level : Level 2 | 2.985
1051123 | 2B10 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12805 | Level 2 | Level : Level 2 | 2.985
1050225 | 2B16 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12557 | Level 2 | Level : Level 2 | 2.985
641635 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2486 | Level 1 | Level : Level 1 | -0.5
712960 | 1B04 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8885 | Level 2 | Level : Level 2 | -1.43
1122530 | 2A09 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 15171 | Level 2 | Level : Level 2 | 2.985
713699 | 1D10 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8974 | Level 2 | Level : Level 2 | -1.35
1013406 | 1C01 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10804 | Level 1 | Level : Level 1 | 2.985
1117828 | 2C19 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 15102 | Level 2 | Level : Level 2 | 0.2
1062800 | 1CC1 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 13496 | Level 1 | Level : Level 1 | 2.985
637031 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1976 | Level 1 | Level : Level 1 | -0.5
1086487 | Level 1 | 0.0677083 | 0.0260417 | 90 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0520833 | 0.0677083 | 90 | 15 mmø-15 mmø-15 mmø | Domestic Cold Water | Domestic Cold Water 1 | 14703 | Level 1 | Level : Level 1 | 0.908719
642085 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2551 | Level 1 | Level : Level 1 | -0.5
1052333 | 2C19 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 13089 | Level 2 | Level : Level 2 | 2.985
635005 | TOF Footing | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Default Sanitary (cskender) | 1674 | Level 1 | Level : Level 1 | -0.5
1014043 | 1E14 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11016 | Level 1 | Level : Level 1 | 2.985
641242 | TOF Footing | 0.109375 | 0.0677083 | 68 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 112 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 2441 | Level 1 | Level : Level 1 | -0.3
639590 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2238 | Level 1 | Level : Level 1 | -0.501123
711571 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8759 | Level 1 | Level : Level 1 | -0.3
634238 | Level 1 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Default Sanitary (cskender) | 1531 | Level 1 | Level : Level 1 | 0.231963
634291 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 1546 | Level 1 | Level : Level 1 | -0.5
1118174 | 1C02 | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 15155 | Level 2 | Level : Level 2 | -1.4
1027758 | 1A16 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11505 | Level 1 | Level : Level 1 | 2.985
639216 | TOF Footing | 0.308781 | 0.0885417 | 32 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 148 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2182 | Level 1 | Level : Level 1 | -0.501123
634187 | TOF Footing | 0.414308 | 0.171875 | 45.0621 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 134.938 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 1520 | Level 1 | Level : Level 1 | -0.5
633525 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1434 | Level 1 | Level : Level 1 | -0.5
1051565 | 2AC1 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12925 | Level 2 | Level : Level 2 | 2.985
1017166 | 1AC2 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 11048 | Level 1 | Level : Level 1 | 2.985
714449 | 1D10 | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9048 | Level 2 | Level : Level 2 | -1.4
636418 | TOF Footing | 0.250128 | 0.130208 | 55 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 55 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 1881 | Level 1 | Level : Level 1 | -0.5
1013666 | 1C09 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10880 | Level 1 | Level : Level 1 | 2.985
1070332 | 2D05 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Hydronic Return | Hydronic Return 1 | 13724 | Level 2 | Level : Level 2 | 4
642459 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2603 | Level 1 | Level : Level 1 | -0.5
1084990 | 1D16 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 14595 | Level 2 | Level : Level 2 | -1.4
700592 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7419 | Level 1 | Level : Level 1 | -0.3
1122596 | 2AC3 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 15188 | Level 2 | Level : Level 2 | 2.985
634652 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 1624 | Level 1 | Level : Level 1 | -0.5
710823 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8654 | Level 1 | Level : Level 1 | -0.3
1049606 | 2D18 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12397 | Level 2 | Level : Level 2 | 2.985
634603 | Level 1 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 1614 | Level 1 | Level : Level 1 | 0
1124660 | 1E08 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Hot Water | Domestic Hot Water 1 | 15305 | Level 2 | Level : Level 2 | -1.4
1016671 | 1CC1 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 11044 | Level 1 | Level : Level 1 | 2.985
1122553 | 2AC3 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Fire Protection Wet | Fire Protection | 15180 | Level 2 | Level : Level 2 | 2.985
636340 | TOF Footing | 0.314353 | 0.130208 | 44.9997 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 135 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 1873 | Level 1 | Level : Level 1 | -0.5
634823 | TOF Footing | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Default Sanitary (cskender) | 1657 | Level 1 | Level : Level 1 | -0.5
639470 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2225 | Level 1 | Level : Level 1 | -0.501123
1052369 | 2C02 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13099 | Level 2 | Level : Level 2 | 2.985
1124456 | 1A16 | 0.0677083 | 0.0260417 | 90 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0520833 | 0.0677083 | 90 | 15 mmø-15 mmø-15 mmø | Domestic Cold Water | Domestic Cold Water 1 | 15300 | Level 2 | Level : Level 2 | -1.5
1113409 | 1DC5 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 15078 | Level 1 | Level : Level 1 | 2.985
710649 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8642 | Level 1 | Level : Level 1 | -0.3
635967 | Level 1 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1833 | Level 1 | Level : Level 1 | 0.232932
1083658 | 1A03 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 14480 | Level 2 | Level : Level 2 | -1.6882
710093 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8576 | Level 1 | Level : Level 1 | -0.3
639184 | Level 1 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 2176 | Level 1 | Level : Level 1 | 0.4
1131785 | 1DC4 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 15646 | Level 1 | Level : Level 1 | 2.985
713324 | 1B10 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8928 | Level 2 | Level : Level 2 | -1.5
636052 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1846 | Level 1 | Level : Level 1 | -0.5
710519 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8628 | Level 1 | Level : Level 1 | -0.3
715525 | 1C02 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9141 | Level 2 | Level : Level 2 | -1.4
1085124 | 1D16 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 14614 | Level 2 | Level : Level 2 | -1.4
1083582 | Level 1 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 14467 | Level 1 | Level : Level 1 | 2.8818
696036 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6859 | Level 2 | Level : Level 2 | 0.2
1085893 | Level 2 | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Sanitary | Sanitary 1 | 14662 | Level 2 | Level : Level 2 | 0.873
1098444 | TOF Footing | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 14943 | Level 1 | Level : Level 1 | -0.5011
1083745 | 1A03 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 14496 | Level 2 | Level : Level 2 | -1.6882
635647 | TOF Footing | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Default Sanitary (cskender) | 1778 | Level 1 | Level : Level 1 | -0.5
640020 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2316 | Level 1 | Level : Level 1 | -0.5
635372 | TOF Footing | 0.314351 | 0.130208 | 45 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 135 | 80 mmø-80 mmø-80 mmø | Sanitary | Default Sanitary (cskender) | 1765 | Level 1 | Level : Level 1 | -0.5
639934 | Level 1 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2295 | Level 1 | Level : Level 1 | 0
639538 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2232 | Level 1 | Level : Level 1 | -0.501123
1125252 | 1C02 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 15371 | Level 2 | Level : Level 2 | -1.35
1084255 | 2C19 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 14535 | Level 2 | Level : Level 2 | 0.2
1124776 | 1E08 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 15317 | Level 2 | Level : Level 2 | -1.35

# IfcFlowFitting: Transition - Generic (1536)
Type - ElementType: Transition - Generic
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Mechanical - Insulation Thickness: 0; Loss Method: 5; K Coefficient Table: Reducer/Coupling/Union/Increaser
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.60.30.11.14; OmniClass Title: Pipework Fittings
PSet_Revit_Type_Mechanical - Loss Method: 1; K Coefficient Table: Reducer/Coupling/Union/Increaser
PSet_Revit_Type_Other - Lookup Table Name: M_Pipe Fitting - Generic.csv; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Transition - Generic:Transition - Generic:Transition - Generic:...) | In | Mark | System Type | System Name | Width Offset | Visibility 3 | Visibility 2 | Visibility 1 | Max Fitting Outside Diameter 12 | Height Offset | Fitting Outside Radius 2 = Insulation Radius 2 | Fitting Outside Radius 1 = Insulation Radius 1 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level | Host | Offset (m) | Tick Size 2 | Tick Size 1 | Nominal Radius 2 | Nominal Radius 1 | Nominal Diameter 2 | Nominal Diameter 1 | Length | Fitting Outside Diameter 2 | Fitting Outside Diameter 1 | Size | OffsetHeight | OffsetWidth
646728 | TOF Footing | 3120 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10.0037 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.501123 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.167728 | 0.164042
690945 | TOF Footing | 6341 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.046875 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0375 | 0.0875 | 0.0410105 | 0.106627 | 0.082021 | 0.213255 | 0.0546875 | 0.09375 | 0.21875 | 65 mmø-25 mmø | 0.106627 | 0.106627
655128 | Level 1 | 3406 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
667007 | 1DC3 | 4726 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.260417 | 10 | 0.0885417 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.50761 | 0.0708333 | 0.104167 | 0.082021 | 0.131234 | 0.164042 | 0.262467 | 0.0651042 | 0.177083 | 0.260417 | 80 mmø-50 mmø | 0.131234 | 0.131234
687978 | Level 1 | 5988 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.786419 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
691095 | TOF Footing | 6379 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
659643 | 1D16 | 3823 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.260417 | 10 | 0.0885417 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.0708333 | 0.104167 | 0.082021 | 0.131234 | 0.164042 | 0.262467 | 0.0651042 | 0.177083 | 0.260417 | 80 mmø-50 mmø | 0.131234 | 0.131234
664317 | 1D07 | 4400 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.63581 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
679395 | TOF Footing | 5030 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.0885417 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0708333 | 0.0875 | 0.082021 | 0.106627 | 0.164042 | 0.213255 | 0.0546875 | 0.177083 | 0.21875 | 65 mmø-50 mmø | 0.106627 | 0.106627
687894 | TOF Footing | 5977 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
645870 | TOF Footing | 2983 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0572917 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.434912 | 0.0458333 | 0.1375 | 0.0524934 | 0.164042 | 0.104987 | 0.328084 | 0.0859375 | 0.114583 | 0.34375 | 100 mmø-32 mmø | 0.164042 | 0.164042
