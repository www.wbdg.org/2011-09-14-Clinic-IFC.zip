Properties of the parts of a building model (IFC2X3), part 30 of 295

# IfcFlowFitting: Standard (800)
Name | In | Level | Host | Offset (m) | Lining Width = Insulation Width | Lining Height = Insulation Height | Size | System Type | System Name | Mark | Takeoff Fixed Length | Takeoff Length Projection | Takeoff Length
M_Rectangular Elbow - Mitered:Standard:Standard:570658 | 1D02 | Level 2 | Level : Level 2 | -0.840924 | 1.31234 | 0.82021 | 400x250-400x250 | Supply Air | Default Supply Air (cskender) | 380 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.353815; Height: 0.82021; Angle: 45 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-17
M_Rectangular Elbow - Mitered:Standard:Standard:570506 | 1DC1 | Level 1 | Level : Level 1 | 3.79 | 0.984252 | 0.984252 | 300x300-300x300 | Return Air | Mechanical Return Air 1 | 9175 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570217 | 2D05 | Roof - Main | Level : Roof - Main | -1.48 | 2.29659 | 0.984252 | 700x300-700x300 | Supply Air | Mechanical Supply Air 1 | 8794 | PSet_Revit_Dimensions - Width: 2.29659; Length1: 0.172394; Height: 0.984252; Angle: 9 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-17
M_Rectangular Elbow - Mitered:Standard:Standard:570604 | 1B02 | Level 2 | Level : Level 2 | -1.116 | 0.492126 | 0.82021 | 150x250-150x250 | Supply Air | Default Supply Air (cskender) | 220 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:1096195 | 1E27 | Level 1 | Level : Level 1 | 3.79 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 1 | 358 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567158 | 1D08 | Level 1 | Level : Level 1 | 3.3 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 1 | 1355 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570128 | 2B15 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8625 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569095 | 2AC1 | Roof - Main | Level : Roof - Main | -0.73 | 1.80446 | 1.31234 | 550x400-550x400 | Return Air | Mechanical Return Air 2 | 6003 | PSet_Revit_Dimensions - Width: 1.80446; Length1: 0.984252; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569110 | 2A04 | Roof - Main | Level : Roof - Main | -0.73 | 1.31234 | 0.492126 | 400x150-400x150 | Return Air | Mechanical Return Air 2 | 6070 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.738189; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568157 | 1D16 | Level 2 | Level : Level 2 | -1.2605 | 0.656168 | 0.82021 | 200x250-200x250 | Supply Air | Mechanical Supply Air 1 | 4350 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570144 | 2B11 | Roof - Main | Level : Roof - Main | -0.68 | 1.31234 | 0.984252 | 400x300-400x300 | Return Air | Mechanical Return Air 2 | 8643 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.738189; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568997 | 2C19 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 5702 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570048 | 2B18 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8498 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570219 | 2D05 | Roof - Main | Level : Roof - Main | -1.48 | 2.29659 | 0.984252 | 700x300-700x300 | Supply Air | Mechanical Supply Air 1 | 8796 | PSet_Revit_Dimensions - Width: 2.29659; Length1: 0.400471; Height: 0.984252; Angle: 31 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-17
M_Rectangular Elbow - Mitered:Standard:Standard:568214 | 1D22 | Level 2 | Level : Level 2 | -1.3605 | 0.82021 | 0.984252 | 250x300-250x300 | Supply Air | Mechanical Supply Air 1 | 4537 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570035 | 2BC1 | Roof - Main | Level : Roof - Main | -0.68 | 2.62467 | 1.31234 | 800x400-800x400 | Return Air | Mechanical Return Air 2 | 8467 | PSet_Revit_Dimensions - Width: 2.62467; Length1: 0.625608; Height: 1.31234; Angle: 45 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:570068 | Level 2 | Level 2 | Level : Level 2 | 4 | 0.492126 | 0.656168 | 150x200-150x200 | Return Air | Mechanical Return Air 2 | 8519 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.656168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570159 | 2B4 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8677 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570014 | 2D08 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8396 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569108 | 2A04 | Level 2 | Level : Level 2 | 3.95 | 0.492126 | 1.31234 | 150x400-150x400 | Return Air | Mechanical Return Air 2 | 6067 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566882 | 1BC4 | Level 1 | Level : Level 1 | 3.3 | 0.656168 | 0.328084 | 200x100-200x100 | Return Air | Mechanical Return Air 1 | 768 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 0.328084; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569034 | 2A08 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.31234 | 150x400-150x400 | Return Air | Mechanical Return Air 2 | 5755 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569130 | 2A01 | Level 2 | Level : Level 2 | 3.95 | 0.984252 | 0.82021 | 300x250-300x250 | Return Air | Mechanical Return Air 2 | 6109 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569057 | 2A12 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 5807 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569967 | 2D15 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8331 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570122 | 2B17 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8620 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568574 | 1E23 | Level 1 | Level : Level 1 | 3.815 | 0.492126 | 0.656168 | 150x200-150x200 | Return Air | Mechanical Return Air 1 | 5431 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.656168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570920 | 1E07 | Level 1 | Level : Level 1 | 3.3 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 1 | 7 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:1138757 | 1B10 | Level 1 | Level : Level 1 | 3.3 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 1 | 1523 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567006 | 1B13 | Level 1 | Level : Level 1 | 3.3 | 0.492126 | 1.47638 | 150x450-150x450 | Return Air | Mechanical Return Air 1 | 1019 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.47638; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570170 | 2D01 | Level 2 | Level : Level 2 | 4 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 2 | 8686 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570062 | 2BC2 | Level 2 | Level : Level 2 | 4 | 0.984252 | 0.984252 | 300x300-300x300 | Return Air | Mechanical Return Air 2 | 8514 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:1094519 | 2D05 | Level 2 | Level : Level 2 | 3.4 | 2.29659 | 1.14829 | 700x350-700x350 | Return Air | Mechanical Return Air 1 | 346 | PSet_Revit_Dimensions - Width: 2.29659; Length1: 1.23031; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:567016 | 1D35 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 1 | 1039 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570164 | 2B7 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8681 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:1138333 | 1C17 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 1 | 1399 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569050 | 2A11 | Roof - Main | Level : Roof - Main | -0.68 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 2 | 5798 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569116 | 2A03 | Level 2 | Level : Level 2 | 3.95 | 0.492126 | 1.31234 | 150x400-150x400 | Return Air | Mechanical Return Air 2 | 6081 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570116 | 2B8 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8612 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567896 | Level 1 | Level 2 | Level : Level 2 | -0.93 | 0.656168 | 1.14829 | 200x350-200x350 | Return Air | Mechanical Return Air 1 | 3444 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.184743; Height: 1.14829; Angle: 34.7704 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-17
M_Rectangular Elbow - Mitered:Standard:Standard:570064 | 2BC2 | Roof - Main | Level : Roof - Main | -0.68 | 1.31234 | 0.82021 | 400x250-400x250 | Return Air | Mechanical Return Air 2 | 8516 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.738189; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570109 | 2B19 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8604 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569101 | 2A01 | Roof - Main | Level : Roof - Main | -0.73 | 1.31234 | 1.14829 | 400x350-400x350 | Return Air | Mechanical Return Air 2 | 6030 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.738189; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567037 | 1DC6 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 1 | 1072 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570097 | 2B24 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8594 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:1120441 | 1DC3 | Level 1 | Level : Level 1 | 3.3 | 1.14829 | 0.656168 | 350x200-350x200 | Return Air | Mechanical Return Air 1 | 1110 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.656168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:1138371 | 1C15 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 1 | 1414 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570103 | 2B01 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8599 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:1138788 | 1A16 | Level 1 | Level : Level 1 | 3.245 | 0.656168 | 0.492126 | 200x150-200x150 | Return Air | Mechanical Return Air 1 | 1531 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570791 | 1DC7 | Level 1 | Level : Level 1 | 3.715 | 3.28084 | 0.984252 | 1000x300-1000x300 | Return Air | Mechanical Return Air 1 | 720 | PSet_Revit_Dimensions - Width: 3.28084; Length1: 1.72244; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:570019 | 2D07 | Level 2 | Level : Level 2 | 4 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 2 | 8400 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568128 | 1C18 | Level 2 | Level : Level 2 | -1.3105 | 0.492126 | 0.82021 | 150x250-150x250 | Supply Air | Mechanical Supply Air 1 | 4279 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570120 | 2B17 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8618 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568120 | 1C18 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 1.31234 | 150x400-150x400 | Return Air | Mechanical Return Air 1 | 4268 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570092 | 2B23 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8590 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:1116600 | 2AC1 | Level 2 | Level : Level 2 | 3.6095 | 0.82021 | 0.82021 | 250x250-250x250 | Supply Air | Default Supply Air (cskender) | 825 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:1120469 | 1C07 | Level 1 | Level : Level 1 | 3.3 | 0.656168 | 1.14829 | 200x350-200x350 | Return Air | Mechanical Return Air 1 | 1116 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567898 | Level 1 | Level 2 | Level : Level 2 | -1.27 | 0.656168 | 1.14829 | 200x350-200x350 | Return Air | Mechanical Return Air 1 | 3450 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.184743; Height: 1.14829; Angle: 34.7704 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-17
M_Rectangular Elbow - Mitered:Standard:Standard:567864 | 1E23 | Level 1 | Level : Level 1 | 3.4095 | 0.984252 | 0.82021 | 300x250-300x250 | Supply Air | Mechanical Supply Air 1 | 3373 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570088 | 2B21 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8588 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568105 | 1C14 | Level 2 | Level : Level 2 | -1.2605 | 0.82021 | 0.984252 | 250x300-250x300 | Supply Air | Mechanical Supply Air 1 | 4183 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570105 | 2B01 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8602 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570086 | 2B21 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8585 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:1099605 | 1C05 | Level 1 | Level : Level 1 | 3.64 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 1 | 377 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Round Takeoff:Standard:Standard:570407 | 2DC2 | Level 2 | Level : Level 2 | 3.6095 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 8940 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569743 | 2D18 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 7788 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569739 | 2D18 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 7773 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569731 | 2D04-A | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 2 | 7759 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Round Takeoff:Standard:Standard:570348 | 2D21 | Level 2 | Level : Level 2 | 3.6095 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 8907 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:570358 | 2D03 | Level 2 | Level : Level 2 | 3.6095 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 8913 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:566731 | 1EC1 | Level 2 | Level : Level 2 | -0.755 | 1.80446 | 0.82021 | 600x250-550x250-550x250 | Return Air | Mechanical Return Air 1 | 229 | PSet_Revit_Dimensions - Width: 1.80446; Length1: 1.06627; Height: 0.82021; Width3: 1.9685; Shoulder: 0.082021; Lining Width3: 1.9685; Length3a: 0.902231; Length3: 0.984252; Length1a: 0.984252; Insulation Width3: 1.9685; PSet_Revit_Mechanical - ASHRAE Table: ER5-5
M_Round Takeoff:Standard:Standard:570280 | 2A12 | Level 2 | Level : Level 2 | 3.6095 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 8870 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:568746 | 1C07 | Level 1 | Level : Level 1 | 3.70948 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5561 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:570397 | 2D07 | Level 2 | Level : Level 2 | 3.40951 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 8934 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:569737 | 2D18 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 7767 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:570298 | 2A04 | Level 2 | Level : Level 2 | 3.6095 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 8880 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:570317 | 2B7 | Level 2 | Level : Level 2 | 3.6095 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 8890 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569772 | 2D17 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 7856 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Tee:Standard:Standard:566889 | 1DC7 | Level 1 | Level : Level 1 | 3.715 | 3.28084 | 0.984252 | 1000x300-1000x300-350x300 | Return Air | Mechanical Return Air 1 | 776 | PSet_Revit_Dimensions - Width: 3.28084; Length1: 0.656168; Height: 0.984252; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 1.64042; Length3: 1.72244; Length1a: 0.574147; Insulation Width3: 1.14829
M_Round Takeoff:Standard:Standard:567958 | 1A01 | Level 2 | Level : Level 2 | -0.860493 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 3734 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:568775 | 1D10 | Level 1 | Level : Level 1 | 3.70948 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5580 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569766 | 2D20 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 7841 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Tee:Standard:Standard:566786 | 1CC1 | Level 2 | Level : Level 2 | -0.93 | 3.28084 | 1.14829 | 1000x350-1000x350-350x350 | Return Air | Mechanical Return Air 1 | 411 | PSet_Revit_Dimensions - Width: 3.28084; Length1: 0.656168; Height: 1.14829; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 1.64042; Length3: 1.72244; Length1a: 0.574147; Insulation Width3: 1.14829
M_Rectangular Cross:Standard:Standard:569779 | 2D17 | Roof - Main | Level : Roof - Main | -1.07048 |  | 0.984252 | 300x300-300x300-250x300-250x300 | Supply Air | Mechanical Supply Air 2 | 7874 | PSet_Revit_Dimensions - Length1: 0.492126; Height: 0.984252; Width3: 0.82021; Shoulder: 0.082021; Lining Width3: 0.82021; Length3a: 0.492126; Length3: 0.574147; Length1a: 0.410105; Insulation Width3: 0.82021; Width4: 0.82021; Width1: 0.984252; Lining Width4: 0.82021; Lining Width1: 0.984252; Insulation Width4: 0.82021; Insulation Width1: 0.984252
M_Round Takeoff:Standard:Standard:569226 | 2CC5 | Roof - Main | Level : Roof - Main | -1.28 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 6345 | 0.328084 | 0.163947 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:569606 | 2B21 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 7420 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:570388 | 2D11 | Level 2 | Level : Level 2 | 3.40948 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 8929 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569573 | 2D18 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 7342 | 0.328084 | 0.163947 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:570417 | 2C06 | Level 2 | Level : Level 2 | 3.6095 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 2 | 8947 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Round Takeoff:Standard:Standard:569215 | 2C13 | Level 2 | Level : Level 2 | 3.40951 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 6281 | 0.328084 | 0.171152 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569486 | 2A11 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 7055 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:568795 | 1D21 | Level 1 | Level : Level 1 | 3.30948 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5592 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569895 | 2B11 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 8177 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Tee:Standard:Standard:566892 | 1DC7 | Level 1 | Level : Level 1 | 3.64 | 4.42913 | 1.47638 | 1350x450-1350x450-250x450 | Return Air | Mechanical Return Air 1 | 782 | PSet_Revit_Dimensions - Width: 4.42913; Length1: 0.492126; Height: 1.47638; Width3: 0.82021; Shoulder: 0.082021; Lining Width3: 0.82021; Length3a: 2.21457; Length3: 2.29659; Length1a: 0.410105; Insulation Width3: 0.82021
M_Round Takeoff:Standard:Standard:569345 | 2CC1 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 6698 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Tee:Standard:Standard:566799 | 1DC3 | Level 2 | Level : Level 2 | -1.27 | 0.984252 | 0.656168 | 400x200-300x200-300x200 | Return Air | Mechanical Return Air 1 | 484 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.738189; Height: 0.656168; Width3: 1.31234; Shoulder: 0.082021; Lining Width3: 1.31234; Length3a: 0.492126; Length3: 0.574147; Length1a: 0.656168; Insulation Width3: 1.31234
M_Round Takeoff:Standard:Standard:569745 | 2D18 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 7791 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569354 | 2CC1 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6714 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568767 | 1A06 | Level 1 | Level : Level 1 | 3.31902 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 5573 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:567947 | 1A03 | Level 2 | Level : Level 2 | -0.87 |  |  | 350ø-350ø | Supply Air | Mechanical Supply Air 1 | 3677 | 0.328084 | 0.938827 | 1.24691 | PSet_Revit_Dimensions - Radius: 0.574147; Lining Diameter: 1.14829; Insulation Diameter: 1.14829; Diameter: 1.14829
M_Rectangular Takeoff:Standard:Standard:570739 | 1C04 | Level 2 | Level : Level 2 | -1.2105 | 0.656168 | 0.82021 | 200x250-200x250 | Supply Air | Mechanical Supply Air 1 | 594 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.656168; W0: 0.656168; Length Multiplier: 0.25; H1: 0.82021; H0: 0.82021; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569764 | 2D20 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 7833 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:569478 | 2AC3 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 7047 | 0.328084 | 0.163951 | 0.328678 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Oval Elbow - Mitered:Standard:Standard:569514 | 2D06 | Roof - Main | Level : Roof - Main | -1.08 | 4.59318 | 1.31234 | 1400/400-1400/400 | Supply Air | Mechanical Supply Air 2 | 7177 | PSet_Revit_Dimensions - Angle: 90 deg; Shoulder Length: 0.082021; Duct Width: 4.59318; Duct Height: 1.31234; PSet_Revit_Mechanical - ASHRAE Table: CF3-1; PSet_Revit_Other - Length 3: 2.37861; Length 2: 2.37861; Length 1: 2.37861
M_Round Takeoff:Standard:Standard:569493 | 2A11 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 7075 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569618 | 2BC4 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 7450 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Oval Transition - Length:Standard:Standard:567889 | Level 1 | Level 2 | Level : Level 2 | -0.87 |  |  | 1500/500-900/500 | Supply Air | Mechanical Supply Air 1 | 3418 | PSet_Revit_Other - Length 1: 1.9685; Width Offset: 10; Width 1: 1.9685; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Height Offset: 10; Height 1: 0; Half Width 2: 1.47638; Half Width 1: 2.46063; Half Height 2: 0.82021; Half Height 1: 0.82021; Height 2: 0; Width 2: 0; PSet_Revit_Dimensions - Duct Width 2: 2.95276; Duct Width 1: 4.92126; Lining Duct Width 2: 2.95276; Lining Duct Width 1: 4.92126; Lining Duct Height 2: 1.64042; Lining Duct Height 1: 1.64042; Duct Length: 1.9685; Insulation Duct Width 2: 2.95276; Insulation Duct Width 1: 4.92126; Insulation Duct Height 2: 1.64042; Insulation Duct Height 1: 1.64042; Duct Height 2: 1.64042; Duct Height 1: 1.64042; OffsetHeight: 0.82021; OffsetWidth: 2.46063
M_Round Takeoff:Standard:Standard:567944 | 1A05 | Level 2 | Level : Level 2 | -0.860486 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 3658 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:567954 | 1AC5 | Level 2 | Level : Level 2 | -0.87 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 3728 | 0.328084 | 0.102021 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:570265 | 2A11 | Level 2 | Level : Level 2 | 3.6095 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 8862 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:570285 | Level 2 | Level 2 | Level : Level 2 | 3.6095 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 2 | 8873 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Rectangular Tee:Standard:Standard:566886 | 1D40 | Level 1 | Level : Level 1 | 3.715 | 3.28084 | 0.984252 | 1000x300-1000x300-350x300 | Return Air | Mechanical Return Air 1 | 772 | PSet_Revit_Dimensions - Width: 3.28084; Length1: 0.656168; Height: 0.984252; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 1.64042; Length3: 1.72244; Length1a: 0.574147; Insulation Width3: 1.14829
M_Rectangular Tee:Standard:Standard:566900 | 1DC7 | Level 1 | Level : Level 1 | 3.64 | 4.42913 | 1.47638 | 1350x450-1350x450-250x450 | Return Air | Mechanical Return Air 1 | 791 | PSet_Revit_Dimensions - Width: 4.42913; Length1: 0.492126; Height: 1.47638; Width3: 0.82021; Shoulder: 0.082021; Lining Width3: 0.82021; Length3a: 2.21457; Length3: 2.29659; Length1a: 0.410105; Insulation Width3: 0.82021
M_Round Takeoff:Standard:Standard:569718 | 2DC2 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 7719 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568736 | 1DC8 | Level 1 | Level : Level 1 | 3.3095 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5546 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:567040 | 1DC7 | Level 1 | Level : Level 1 | 3.64 | 4.42913 | 1.47638 | 1350x450-1350x450-350x450 | Return Air | Mechanical Return Air 1 | 1075 | PSet_Revit_Dimensions - Width: 4.42913; Length1: 0.656168; Height: 1.47638; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 2.21457; Length3: 2.29659; Length1a: 0.574147; Insulation Width3: 1.14829
M_Round Takeoff:Standard:Standard:570754 | 1D13 | Level 2 | Level : Level 2 | -1.0605 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 645 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:566794 | 1D05 | Level 2 | Level : Level 2 | -1.27 | 1.14829 | 0.656168 | 350x200-350x200-200x200 | Return Air | Mechanical Return Air 1 | 477 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.410105; Height: 0.656168; Width3: 0.656168; Shoulder: 0.082021; Lining Width3: 0.656168; Length3a: 0.574147; Length3: 0.656168; Length1a: 0.328084; Insulation Width3: 0.656168
M_Round Takeoff:Standard:Standard:569616 | 2BC4 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 7439 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:567930 | 1AC5 | Level 2 | Level : Level 2 | -0.87 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 3610 | 0.328084 | 0.308084 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569664 | 2BC3 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 7547 | 0.328084 | 0.163947 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:569708 | 2DC2 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 7690 | 0.328084 | 0.107921 | 0.328338 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569782 | 2D18 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 7880 | 0.328084 | 0.390105 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Tee:Standard:Standard:567013 | 1DC7 | Level 1 | Level : Level 1 | 3.64 | 4.42913 | 1.47638 | 1350x450-1350x450-250x450 | Return Air | Mechanical Return Air 1 | 1035 | PSet_Revit_Dimensions - Width: 4.42913; Length1: 0.492126; Height: 1.47638; Width3: 0.82021; Shoulder: 0.082021; Lining Width3: 0.82021; Length3a: 2.21457; Length3: 2.29659; Length1a: 0.410105; Insulation Width3: 0.82021
M_Round Takeoff:Standard:Standard:567980 | 1A16 | Level 2 | Level : Level 2 | -0.87 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 3799 | 0.328084 | 0.129887 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Oval Transition - Length:Standard:Standard:569574 | 2D18 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 850/400-500/400 | Supply Air | Mechanical Supply Air 2 | 7343 | PSet_Revit_Other - Length 1: 1.14829; Width Offset: 10; Width 1: 1.14829; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Height Offset: 10; Height 1: 0; Half Width 2: 0.82021; Half Width 1: 1.39436; Half Height 2: 0.656168; Half Height 1: 0.656168; Height 2: 0; Width 2: 0; PSet_Revit_Dimensions - Duct Width 2: 1.64042; Duct Width 1: 2.78871; Lining Duct Width 2: 1.64042; Lining Duct Width 1: 2.78871; Lining Duct Height 2: 1.31234; Lining Duct Height 1: 1.31234; Duct Length: 0.984252; Insulation Duct Width 2: 1.64042; Insulation Duct Width 1: 2.78871; Insulation Duct Height 2: 1.31234; Insulation Duct Height 1: 1.31234; Duct Height 2: 1.31234; Duct Height 1: 1.31234; OffsetHeight: 0.656168; OffsetWidth: 1.39436
M_Round Takeoff:Standard:Standard:569497 | Level 2 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 7122 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Takeoff:Standard:Standard:566709 | 1D16 | Level 2 | Level : Level 2 | -0.93 | 3.77297 | 1.31234 | 1150x400-1150x400 | Return Air | Mechanical Return Air 1 | 35 | 0.943241 | 0.02 | 0.943241 | PSet_Revit_Dimensions - W1: 3.77297; W0: 3.77297; Length Multiplier: 0.25; H1: 1.31234; H0: 1.31234; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:567875 | Level 1 | Level 1 | Level : Level 1 | 3.4095 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 3404 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:568060 | 1CC2 | Level 2 | Level : Level 2 | -1.22 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 4066 | 0.328084 | 0.0577872 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Takeoff:Standard:Standard:569948 | 2D19 | Roof - Main | Level : Roof - Main | -0.68 | 1.80446 | 0.656168 | 550x200-550x200 | Return Air | Mechanical Return Air 2 | 8314 | 0.451115 | 0.02 | 0.451115 | PSet_Revit_Dimensions - W1: 1.80446; W0: 1.80446; Length Multiplier: 0.25; H1: 0.656168; H0: 0.656168; ConnectorOffset: 0
M_Rectangular Tee:Standard:Standard:566832 | 1DC1 | Level 2 | Level : Level 2 | -0.78 | 2.13255 | 0.82021 | 650x250-650x250-250x250 | Return Air | Mechanical Return Air 1 | 596 | PSet_Revit_Dimensions - Width: 2.13255; Length1: 0.492126; Height: 0.82021; Width3: 0.82021; Shoulder: 0.082021; Lining Width3: 0.82021; Length3a: 1.06627; Length3: 1.14829; Length1a: 0.410105; Insulation Width3: 0.82021; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Round Takeoff:Standard:Standard:569580 | 2D18 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 350ø-350ø | Supply Air | Mechanical Supply Air 2 | 7351 | 0.328084 | 0.358502 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.574147; Lining Diameter: 1.14829; Insulation Diameter: 1.14829; Diameter: 1.14829
M_Rectangular Tee:Standard:Standard:566772 | 1DC1 | Level 2 | Level : Level 2 | -0.78 | 2.13255 | 0.984252 | 650x300-650x300-250x300 | Return Air | Mechanical Return Air 1 | 376 | PSet_Revit_Dimensions - Width: 2.13255; Length1: 0.492126; Height: 0.984252; Width3: 0.82021; Shoulder: 0.082021; Lining Width3: 0.82021; Length3a: 1.06627; Length3: 1.14829; Length1a: 0.410105; Insulation Width3: 0.82021; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Round Takeoff:Standard:Standard:570355 | 2D21 | Level 2 | Level : Level 2 | 3.6095 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 8911 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Tee:Standard:Standard:566826 | 1A16 | Level 2 | Level : Level 2 | -1.325 | 1.64042 | 0.656168 | 500x200-500x200-350x200 | Return Air | Mechanical Return Air 1 | 584 | PSet_Revit_Dimensions - Width: 1.64042; Length1: 0.656168; Height: 0.656168; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 0.82021; Length3: 0.902231; Length1a: 0.574147; Insulation Width3: 1.14829; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Oval Tap - Straight:Standard:Standard:569570 | 2DC2 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 850/400-850/400 | Supply Air | Mechanical Supply Air 2 | 7316 | 0.697178 | 0.676168 | 0.697178 | PSet_Revit_Dimensions - Length Multiplier: 0.25; Duct Width 2: 2.78871; Duct Width 1: 2.78871; Duct Height 2: 1.31234; Duct Height 1: 1.31234; Lining Width 2: 2.78871; Lining Height 2: 1.31234; Insulation Width 2: 2.78871; Insulation Height 2: 1.31234; Lining Width 1: 2.78871; Lining Height 1: 1.31234; Insulation Width 1: 2.78871; Insulation Height 1: 1.31234
M_Round Takeoff:Standard:Standard:569906 | 2BC6 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 8196 | 0.328084 | 0.067884 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:570239 | 2CC1 | Level 2 | Level : Level 2 | 3.6095 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 8848 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569648 | 2B15 | Level 2 | Level : Level 2 | 3.6095 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 7511 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:570322 | 2B8 | Level 2 | Level : Level 2 | 3.6095 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 8893 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:566751 | 1DC1 | Level 2 | Level : Level 2 | -0.93 | 4.59318 | 1.9685 | 1400x600-1400x600-650x600 | Return Air | Mechanical Return Air 1 | 291 | PSet_Revit_Dimensions - Width: 4.59318; Length1: 1.14829; Height: 1.9685; Width3: 2.13255; Shoulder: 0.082021; Lining Width3: 2.13255; Length3a: 2.29659; Length3: 2.37861; Length1a: 1.06627; Insulation Width3: 2.13255
M_Round Takeoff:Standard:Standard:567962 | 1A01 | Level 2 | Level : Level 2 | -0.860492 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 3742 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569340 | 2C03 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6663 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569223 | 2C17 | Roof - Main | Level : Roof - Main | -1.27048 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 2 | 6335 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Oval to Round Transition - Length:Standard:Standard:569526 | 2BC3 | Roof - Main | Level : Roof - Main | -1.08 | 1.9685 | 1.31234 | 600/400-400ø | Supply Air | Mechanical Supply Air 2 | 7197 | PSet_Revit_Dimensions - Duct Width: 1.9685; Duct Height: 1.31234; Duct Length: 0.984252; OffsetHeight: 0.656168; OffsetWidth: 0.984252; Duct Radius: 0.656168; Lining Radius: 0.656168; Insulation Radius: 0.656168; Duct Diameter: 1.31234; PSet_Revit_Other - Length 1: 0.656168; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Vertical Profile Offset 2: 0.328084; Half Height: 0.656168; Vertical Profile Offset 1: 0.328084; Offset Width 1: 10; Offset Height 1: 10; Half Width: 0.984252
M_Round Takeoff:Standard:Standard:569768 | 2D18 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 7850 | 0.328084 | 0.192328 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Takeoff:Standard:Standard:569955 | 2D19 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8322 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Rectangular Tee:Standard:Standard:566775 | 1D20 | Level 2 | Level : Level 2 | -0.93 | 4.59318 | 1.9685 | 1400x600-1400x600-450x600 | Return Air | Mechanical Return Air 1 | 385 | PSet_Revit_Dimensions - Width: 4.59318; Length1: 0.82021; Height: 1.9685; Width3: 1.47638; Shoulder: 0.082021; Lining Width3: 1.47638; Length3a: 2.29659; Length3: 2.37861; Length1a: 0.738189; Insulation Width3: 1.47638
M_Rectangular Tee:Standard:Standard:566860 | 1B08 | Level 1 | Level : Level 1 | 3.3 | 1.14829 | 0.492126 | 350x150-350x150-200x150 | Return Air | Mechanical Return Air 1 | 718 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.410105; Height: 0.492126; Width3: 0.656168; Shoulder: 0.082021; Lining Width3: 0.656168; Length3a: 0.574147; Length3: 0.656168; Length1a: 0.328084; Insulation Width3: 0.656168
M_Round Takeoff:Standard:Standard:567910 | 1A16 | Level 2 | Level : Level 2 | -0.87 |  |  | 450ø-450ø | Supply Air | Mechanical Supply Air 1 | 3526 | 0.369094 | 0.555304 | 0.369094 | PSet_Revit_Dimensions - Radius: 0.738189; Lining Diameter: 1.47638; Insulation Diameter: 1.47638; Diameter: 1.47638
M_Round Takeoff:Standard:Standard:569799 | 2D18 | Roof - Main | Level : Roof - Main | -1.27052 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 7919 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Takeoff:Standard:Standard:567214 | 1C18 | Level 1 | Level : Level 1 | 3.64 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 1 | 1447 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:570242 | 2C22 | Level 2 | Level : Level 2 | 3.6095 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 8850 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:567221 | 1C18 | Level 1 | Level : Level 1 | 3.64 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 1 | 1450 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569611 | 2BC3 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 7431 | 0.328084 | 0.107919 | 0.328292 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568605 | 1C14 | Level 1 | Level : Level 1 | 3.3095 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5463 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:1100909 | 1D25 | Level 1 | Level : Level 1 | 3.3 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 410 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:566816 | 1A16 | Level 2 | Level : Level 2 | -1.325 | 0.656168 | 0.656168 | 200x200-200x200-200x200 | Return Air | Mechanical Return Air 1 | 564 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 0.656168; Width3: 0.656168; Shoulder: 0.082021; Lining Width3: 0.656168; Length3a: 0.328084; Length3: 0.410105; Length1a: 0.328084; Insulation Width3: 0.656168; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Round Takeoff:Standard:Standard:568608 | Level 1 | Level 1 | Level : Level 1 | 3.3095 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 5465 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:569453 | 2A01 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 6942 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:569467 | 2A06 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 2 | 7014 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Round Takeoff:Standard:Standard:569245 | 2CC3 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 400ø-400ø | Supply Air | Mechanical Supply Air 2 | 6386 | 0.328084 | 0.676168 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.656168; Lining Diameter: 1.31234; Insulation Diameter: 1.31234; Diameter: 1.31234
M_Round Takeoff:Standard:Standard:569253 | 2CC1 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 6405 | 0.328084 | 0.163947 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:567757 | 1D35 | Level 1 | Level : Level 1 | 3.37951 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 3080 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569218 | 2C17 | Roof - Main | Level : Roof - Main | -1.28 |  |  | 350ø-350ø | Supply Air | Mechanical Supply Air 2 | 6288 | 0.328084 | 0.554147 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.574147; Lining Diameter: 1.14829; Insulation Diameter: 1.14829; Diameter: 1.14829
M_Round Takeoff:Standard:Standard:568016 | 1AC3 | Level 2 | Level : Level 2 | -0.87 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 3948 | 0.328084 | 0.0884751 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:567218 | 1C18 | Level 1 | Level : Level 1 | 3.64 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 1 | 1449 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
