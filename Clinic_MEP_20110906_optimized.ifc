Properties of the parts of a building model (IFC2X3), part 48 of 295

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1108447
PSet_Revit_Identity Data - Mark: 108
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.7105 m
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1110433
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1110433
PSet_Revit_Identity Data - Mark: 109
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.04171 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.139788; Hydraulic Diameter: 0.492126; Section: 144; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 4.53073; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1111605
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1111605
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 2.84322; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.0877229; Hydraulic Diameter: 0.492126; Section: 207; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Identity Data - Mark: 118
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.653717 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1112950
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1112950
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 6.25459; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.192975; Hydraulic Diameter: 0.492126; Section: 239; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Identity Data - Mark: 125
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.43806 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1114555
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:1114555
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.207588; Hydraulic Diameter: 0.492126; Section: 252; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Identity Data - Mark: 126
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.54696 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 6.7282; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1114762
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:1114762
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.46886 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 127
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.148426; Hydraulic Diameter: 0.656168; Section: 247; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.52213; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1114884
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:1114884
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 10.9074; Friction: 0.0432181; Pressure Drop: 0.207291; Velocity Pressure: 2.02571; Reynolds number: 66456.3
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.10233; Hydraulic Diameter: 0.984252; Section: 310; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Dimensions - Diameter: 0.984252; Length: 1.46194 m
PSet_Revit_Identity Data - Mark: 220
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1115248
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:1115248
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.11799; Hydraulic Diameter: 0.656168; Section: 119; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 225
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.21001; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.16767 m
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1115858
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:1115858
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.30671 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.451217; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.10742; Hydraulic Diameter: 0.82021; Section: 152; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Identity Data - Mark: 234
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1115935
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:1115935
PSet_Revit_Identity Data - Mark: 235
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.0668917; Hydraulic Diameter: 0.984252; Section: 20; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 10.9074; Friction: 0.0432181; Pressure Drop: 0.135503; Velocity Pressure: 2.02571; Reynolds number: 66456.3
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Diameter: 0.984252; Length: 0.95565 m
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1117466
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1117466
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.0671617; Hydraulic Diameter: 0.492126; Section: 400; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.500493 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 236
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 2.1768; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1119070
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1119070
PSet_Revit_Identity Data - Mark: 237
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.113944; Hydraulic Diameter: 0.492126; Section: 572; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 3.69308; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.849117 m
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1119072
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1119072
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.31446 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 238
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 5.71698; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.176388; Hydraulic Diameter: 0.492126; Section: 192; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1119241
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1119241
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.0969286; Hydraulic Diameter: 0.656168; Section: 179; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 0.959234 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 239
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 0.994017; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1119298
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1119298
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Identity Data - Mark: 240
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.122565; Hydraulic Diameter: 0.492126; Section: 362; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.913362 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 3.9725; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1119300
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1119300
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.540987 m
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 241
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.0725957; Hydraulic Diameter: 0.492126; Section: 364; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 2.35292; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1119303
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1119303
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.0725957; Hydraulic Diameter: 0.492126; Section: 366; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Identity Data - Mark: 242
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 2.35292; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.540987 m
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1119414
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1119414
PSet_Revit_Identity Data - Mark: 243
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.0671426; Hydraulic Diameter: 0.492126; Section: 35; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 2.17618; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.500351 m
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1119981
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1119981
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 3.92541; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Identity Data - Mark: 244
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.902535 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.121112; Hydraulic Diameter: 0.492126; Section: 449; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1119984
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1119984
PSet_Revit_Identity Data - Mark: 245
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 3.39522; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.104754; Hydraulic Diameter: 0.492126; Section: 451; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.780634 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1120159
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1120159
PSet_Revit_Identity Data - Mark: 246
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.186394; Hydraulic Diameter: 0.492126; Section: 273; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.38902 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 6.04127; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1120351
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1120351
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.356343 m
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 1.54985; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Identity Data - Mark: 247
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.047818; Hydraulic Diameter: 0.492126; Section: 20; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1121407
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1121407
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.19069; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.14903 m
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.116107; Hydraulic Diameter: 0.656168; Section: 637; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Identity Data - Mark: 248
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1122129
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:1122129
PSet_Revit_Identity Data - Mark: 249
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.27292 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.170815; Hydraulic Diameter: 0.492126; Section: 182; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 5.53634; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1122497
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:1122497
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.219535; Hydraulic Diameter: 0.492126; Section: 75; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.63599 m
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 250
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 7.11542; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1125395
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1125395
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 5.01193; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.15235 m
PSet_Revit_Identity Data - Mark: 251
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.154635; Hydraulic Diameter: 0.492126; Section: 368; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1125434
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1125434
PSet_Revit_Identity Data - Mark: 252
