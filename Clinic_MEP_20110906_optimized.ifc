Properties of the parts of a building model (IFC2X3), part 230 of 295

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568375
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 20.5599; Friction: 0.220945; Pressure Drop: 1.80496; Velocity Pressure: 7.19746; Reynolds number: 78291.9
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568379
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568379
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.2 m; Top Elevation: 3.4 m; Equivalent Diameter: 0.499795; Size Lock: no; Loss Coefficient: 0.25005; Hydraulic Diameter: 0.437445; Section: 418; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.12779 m2
PSet_Revit_Identity Data - Mark: 1075
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 38.5499; Friction: 1.026; Pressure Drop: 6.32716; Velocity Pressure: 25.3036; Reynolds number: 104389
PSet_Revit_Dimensions - Size: 100x200; Width: 0.328084; Height: 0.656168; Length: 1.87964 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.3 m; Start Offset: 3.3 m; End Offset: 3.3 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568401
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568401
PSet_Revit_Identity Data - Mark: 1085
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.6745 m; Top Elevation: 3.92452 m; Equivalent Diameter: 0.688942; Size Lock: no; Loss Coefficient: 0.445482; Hydraulic Diameter: 0.615157; Section: 372; Insulation Thickness: 0; Lining Thickness: 0; Area: 4.01543 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 37.1829; Friction: 0.636831; Pressure Drop: 10.487; Velocity Pressure: 23.5408; Reynolds number: 141592
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.79953 m; Start Offset: 3.79953 m; End Offset: 3.7995 m; Slope: 0
PSet_Revit_Dimensions - Size: 150x250; Width: 0.492126; Height: 0.82021; Length: 5.01929 m
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568427
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568427
PSet_Revit_Identity Data - Mark: 1102
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.6745 m; Top Elevation: 3.92452 m; Equivalent Diameter: 0.688942; Size Lock: no; Loss Coefficient: 0.102657; Hydraulic Diameter: 0.615157; Section: 394; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.815431 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.79952 m; Start Offset: 3.79952 m; End Offset: 3.7995 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 150x250; Width: 0.492126; Height: 0.82021; Length: 1.01929 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 20.5599; Friction: 0.220945; Pressure Drop: 0.738867; Velocity Pressure: 7.19746; Reynolds number: 78291.9
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568444
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568444
PSet_Revit_Mechanical - Airflow - Flow: 16.5979; Additional Flow: 0; Velocity: 24.6719; Friction: 0.215723; Pressure Drop: 0.463991; Velocity Pressure: 10.3643; Reynolds number: 125267
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.70948 m; Start Offset: 3.70948 m; End Offset: 3.70948 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.58448 m; Top Elevation: 3.83448 m; Equivalent Diameter: 0.896625; Size Lock: no; Loss Coefficient: 0.044768; Hydraulic Diameter: 0.82021; Section: 166; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.655582 m2
PSet_Revit_Identity Data - Mark: 1107
PSet_Revit_Dimensions - Size: 250x250; Width: 0.82021; Height: 0.82021; Length: 0.655582 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568452
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568452
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.442689 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0385344; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.02231 m; Top Elevation: 3.465 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0308384; Hydraulic Diameter: 0.984252; Section: 143; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.531227 m2
PSet_Revit_Identity Data - Mark: 1110
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.02231 m; Start Offset: 3.02231 m; End Offset: 3.465 m
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568455
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568455
PSet_Revit_Dimensions - Size: 350x150; Width: 1.14829; Height: 0.492126; Length: 0.457334 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.08267 m; Top Elevation: 3.54 m; Equivalent Diameter: 0.804054; Size Lock: no; Loss Coefficient: 0.0434843; Hydraulic Diameter: 0.688976; Section: 145; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.457334 m2
PSet_Revit_Identity Data - Mark: 1111
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.54 m; Start Offset: 3.54 m; End Offset: 3.08267 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 14.6857; Friction: 0.106423; Pressure Drop: 0.159682; Velocity Pressure: 3.67217; Reynolds number: 62633.6
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568464
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568464
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.565 m; Top Elevation: 3.715 m; Equivalent Diameter: 0.804054; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 0.688976; Section: 320; Insulation Thickness: 0; Lining Thickness: 0; Area: 2.32 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.64 m; Start Offset: 3.64 m; End Offset: 3.64 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1114
PSet_Revit_Dimensions - Size: 350x150; Width: 1.14829; Height: 0.492126; Length: 2.32 m
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568466
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568466
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.565 m; Top Elevation: 3.715 m; Equivalent Diameter: 0.804054; Size Lock: no; Loss Coefficient: 0.053246; Hydraulic Diameter: 0.688976; Section: 151; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.56 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 350x150; Width: 1.14829; Height: 0.492126; Length: 0.56 m
PSet_Revit_Identity Data - Mark: 1115
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.64 m; Start Offset: 3.64 m; End Offset: 3.64 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 14.6857; Friction: 0.106423; Pressure Drop: 0.195529; Velocity Pressure: 3.67217; Reynolds number: 62633.6
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568469
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568469
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.02231 m; Start Offset: 3.02231 m; End Offset: 3.465 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.02231 m; Top Elevation: 3.465 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0308384; Hydraulic Diameter: 0.984252; Section: 151; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.531227 m2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0385344; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1116
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.442689 m
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568477
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568477
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.175 m; Start Offset: 3.175 m; End Offset: 3.08267 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 11.0142; Friction: 0.050578; Pressure Drop: 0.0153217; Velocity Pressure: 2.0656; Reynolds number: 56939.6
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.08267 m; Top Elevation: 3.175 m; Equivalent Diameter: 0.939775; Size Lock: no; Loss Coefficient: 0.00741759; Hydraulic Diameter: 0.835123; Section: 157; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.101567 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 350x200; Width: 1.14829; Height: 0.656168; Length: 0.092334 m
PSet_Revit_Identity Data - Mark: 1119
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568480
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568480
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.54 m; Start Offset: 3.54 m; End Offset: 3.08267 m
PSet_Revit_Dimensions - Size: 350x150; Width: 1.14829; Height: 0.492126; Length: 0.457334 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 14.6857; Friction: 0.106423; Pressure Drop: 0.159682; Velocity Pressure: 3.67217; Reynolds number: 62633.6
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.08267 m; Top Elevation: 3.54 m; Equivalent Diameter: 0.804054; Size Lock: no; Loss Coefficient: 0.0434843; Hydraulic Diameter: 0.688976; Section: 159; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.457334 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1120
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568483
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568483
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.54 m; Start Offset: 3.54 m; End Offset: 3.08267 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 14.6857; Friction: 0.106423; Pressure Drop: 0.159682; Velocity Pressure: 3.67217; Reynolds number: 62633.6
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.08267 m; Top Elevation: 3.54 m; Equivalent Diameter: 0.804054; Size Lock: no; Loss Coefficient: 0.0434843; Hydraulic Diameter: 0.688976; Section: 161; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.457334 m2
PSet_Revit_Dimensions - Size: 350x150; Width: 1.14829; Height: 0.492126; Length: 0.457334 m
PSet_Revit_Identity Data - Mark: 1121
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568523
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568523
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Default Supply Air (cskender); Bottom Elevation: 3.7055 m; Top Elevation: 3.8555 m; Equivalent Diameter: 0.688942; Size Lock: no; Loss Coefficient: 0.18535; Hydraulic Diameter: 0.615157; Section: 0; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.47229 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1138
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.7805 m; Start Offset: 3.7805 m; End Offset: 3.7805 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 20.5599; Friction: 0.220945; Pressure Drop: 1.33405; Velocity Pressure: 7.19746; Reynolds number: 78291.9
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 250x150; Width: 0.82021; Height: 0.492126; Length: 1.84036 m
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568560
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568560
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 2.9016 m; Start Offset: 2.9016 m; End Offset: 3.1 m
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.1984 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 2.9016 m; Top Elevation: 3.1 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0138208; Hydraulic Diameter: 0.984252; Section: 211; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.23808 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1150
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0172699; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568568
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568568
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.08267 m; Top Elevation: 3.2 m; Equivalent Diameter: 0.804054; Size Lock: no; Loss Coefficient: 0.0111564; Hydraulic Diameter: 0.688976; Section: 216; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.117334 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.2 m; Start Offset: 3.2 m; End Offset: 3.08267 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 14.6857; Friction: 0.106423; Pressure Drop: 0.0409681; Velocity Pressure: 3.67217; Reynolds number: 62633.6
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1152
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 350x150; Width: 1.14829; Height: 0.492126; Length: 0.117334 m
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568571
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568571
PSet_Revit_Dimensions - Size: 200x150; Width: 0.656168; Height: 0.492126; Length: 0.119516 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.74 m; Top Elevation: 3.89 m; Equivalent Diameter: 0.619601; Size Lock: no; Loss Coefficient: 0.0127331; Hydraulic Diameter: 0.56243; Section: 219; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.083661 m2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 25.6999; Friction: 0.365194; Pressure Drop: 0.143197; Velocity Pressure: 11.246; Reynolds number: 89476.5
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.815 m; Start Offset: 3.815 m; End Offset: 3.815 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1153
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568572
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568572
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.08267 m; Top Elevation: 3.53393 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.031436; Hydraulic Diameter: 0.984252; Section: 218; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.541522 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.08267 m; Start Offset: 3.08267 m; End Offset: 3.53393 m
PSet_Revit_Identity Data - Mark: 1154
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.451268 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0392811; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568582
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568582
PSet_Revit_Dimensions - Size: 350x150; Width: 1.14829; Height: 0.492126; Length: 0.191439 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.715 m; Top Elevation: 3.865 m; Equivalent Diameter: 0.804054; Size Lock: no; Loss Coefficient: 0.0182024; Hydraulic Diameter: 0.688976; Section: 226; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.191439 m2
PSet_Revit_Identity Data - Mark: 1156
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 14.6857; Friction: 0.106423; Pressure Drop: 0.0668425; Velocity Pressure: 3.67217; Reynolds number: 62633.6
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.79 m; Start Offset: 3.79 m; End Offset: 3.79 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568583
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568583
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.486623 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0423586; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Identity Data - Mark: 1157
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.02231 m; Top Elevation: 3.50893 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0338989; Hydraulic Diameter: 0.984252; Section: 225; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.583948 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.02231 m; Start Offset: 3.02231 m; End Offset: 3.50893 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568588
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568588
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 20.5599; Friction: 0.220945; Pressure Drop: 0.483998; Velocity Pressure: 7.19746; Reynolds number: 78291.9
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.02231 m; Top Elevation: 3.69 m; Equivalent Diameter: 0.688942; Size Lock: no; Loss Coefficient: 0.0672456; Hydraulic Diameter: 0.615157; Section: 228; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.534151 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.69 m; Start Offset: 3.69 m; End Offset: 3.02231 m
PSet_Revit_Dimensions - Size: 250x150; Width: 0.82021; Height: 0.492126; Length: 0.667689 m
PSet_Revit_Identity Data - Mark: 1158
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Taps:568973
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Taps:568973
PSet_Revit_Dimensions - Size: 1200x500; Width: 3.93701; Height: 1.64042; Length: 13.075 m
PSet_Revit_Constraints - Horizontal Justification: 1; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.95 m; Start Offset: 3.95 m; End Offset: 3.95 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.7 m; Top Elevation: 4.2 m; Equivalent Diameter: 2.71432; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 2.31589; Section: 210; Insulation Thickness: 0; Lining Thickness: 0; Area: 44.455 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1159
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
