Properties of the parts of a building model (IFC2X3), part 47 of 295

# IfcFlowFitting: Transition - Generic (1536)
Name (M_Transition - Generic:Transition - Generic:Transition - Generic:...) | In | Mark | System Type | System Name | Width Offset | Visibility 3 | Visibility 2 | Visibility 1 | Max Fitting Outside Diameter 12 | Height Offset | Fitting Outside Radius 2 = Insulation Radius 2 | Fitting Outside Radius 1 = Insulation Radius 1 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level | Host | Offset (m) | Tick Size 2 | Tick Size 1 | Nominal Radius 2 | Nominal Radius 1 | Nominal Diameter 2 | Nominal Diameter 1 | Length | Fitting Outside Diameter 2 | Fitting Outside Diameter 1 | Size | OffsetHeight | OffsetWidth
639474 | TOF Footing | 2228 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.501123 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
713880 | 2D13 | 9000 | Domestic Hot Water | Domestic Hot Water 1 | 10 | yes | no | no | 0.135417 | 10 | 0.0677083 | 0.0260417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.2 | 0.0541667 | 0.0208333 | 0.0656168 | 0.0246063 | 0.131234 | 0.0492126 | 0.0338542 | 0.135417 | 0.0520833 | 40 mmø-15 mmø | 0.0246063 | 0.0246063
705943 | TOF Footing | 8050 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.25 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
695921 | Level 2 | 6851 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.2 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
696060 | Level 2 | 6865 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.5 | 0.0375 | 0.0708333 | 0.0410105 | 0.082021 | 0.082021 | 0.164042 | 0.0442708 | 0.09375 | 0.177083 | 50 mmø-25 mmø | 0.082021 | 0.082021
709696 | TOF Footing | 8533 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1125954 | 1AC3 | 15420 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.35 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
1098443 | TOF Footing | 14942 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.260417 | 10 | 0.130208 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5011 | 0.104167 | 0.0541667 | 0.131234 | 0.0656168 | 0.262467 | 0.131234 | 0.0651042 | 0.260417 | 0.135417 | 80 mmø-40 mmø | 0.0656168 | 0.0656168
710827 | TOF Footing | 8657 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.114583 | 10 | 0.0260417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0458333 | 0.0246063 | 0.0524934 | 0.0492126 | 0.104987 | 0.0286458 | 0.0520833 | 0.114583 | 32 mmø-15 mmø | 0.0524934 | 0.0524934
1083749 | 1A03 | 14499 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
641385 | TOF Footing | 2466 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.177083 | 10 | 0.0885417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0708333 | 0.0458333 | 0.082021 | 0.0524934 | 0.164042 | 0.104987 | 0.0442708 | 0.177083 | 0.114583 | 50 mmø-32 mmø | 0.0524934 | 0.0524934
639662 | TOF Footing | 2251 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.177083 | 10 | 0.0885417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.501123 | 0.0708333 | 0.0458333 | 0.082021 | 0.0524934 | 0.164042 | 0.104987 | 0.0442708 | 0.177083 | 0.114583 | 50 mmø-32 mmø | 0.0524934 | 0.0524934
1099212 | TOF Footing | 15000 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.260417 | 10 | 0.130208 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.104167 | 0.0541667 | 0.131234 | 0.0656168 | 0.262467 | 0.131234 | 0.0651042 | 0.260417 | 0.135417 | 80 mmø-40 mmø | 0.0656168 | 0.0656168
640024 | TOF Footing | 2319 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
713418 | 1B10 | 8944 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1124664 | 1E08 | 15308 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
703321 | TOF Footing | 7749 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1113330 | 1DC5 | 15073 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
1049577 | 2D18 | 12392 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1124054 | 1A16 | 15243 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.35 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1086490 | Level 1 | 14705 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.0520833 | 10 | 0.0208333 | 0.0260417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.908719 | 0.0166667 | 0.0208333 | 0.0164042 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0130208 | 0.0416667 | 0.0520833 | 15 mmø-10 mmø | 0.0246063 | 0.0246063
1098218 | TOF Footing | 14906 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.260417 | 10 | 0.130208 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.104167 | 0.0541667 | 0.131234 | 0.0656168 | 0.262467 | 0.131234 | 0.0651042 | 0.260417 | 0.135417 | 80 mmø-40 mmø | 0.0656168 | 0.0656168
1083083 | 2A06 | 14419 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.2 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
712870 | 1B03 | 8879 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
710738 | TOF Footing | 8652 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
635376 | TOF Footing | 1768 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.260417 | 10 | 0.0885417 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0708333 | 0.104167 | 0.082021 | 0.131234 | 0.164042 | 0.262467 | 0.0651042 | 0.177083 | 0.260417 | 80 mmø-50 mmø | 0.131234 | 0.131234
1125942 | Level 1 | 15419 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0364583 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0291667 | 0.0375 | 0.0328084 | 0.0410105 | 0.0656168 | 0.082021 | 0.0234375 | 0.0729167 | 0.09375 | 25 mmø-20 mmø | 0.0410105 | 0.0410105
639944 | Level 1 | 2305 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0572917 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0 | 0.0458333 | 0.1375 | 0.0524934 | 0.164042 | 0.104987 | 0.328084 | 0.0859375 | 0.114583 | 0.34375 | 100 mmø-32 mmø | 0.164042 | 0.164042
1098603 | 1B08 | 14961 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -0.376869 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
1113413 | 1DC5 | 15081 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
635651 | TOF Footing | 1781 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.447613 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
1099327 | Level 1 | 15006 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.327744 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1124779 | 1E08 | 15319 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.35 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
1083125 | 2A06 | 14421 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.610319 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
1084313 | 2C12 | 14537 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.2 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
1124778 | 1E08 | 15318 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.35 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084

# IfcFlowFitting: Wye 45 Deg Double - PVC - Sch 40 - DWV (5)
Type - ElementType: Wye 45 Deg Double - PVC - Sch 40 - DWV
PSet_Revit_Mechanical - Insulation Thickness: 0; System Type: Sanitary; Loss Method: 5
PSet_Revit_Other - Min Angle 12: 45 deg; Max Angle 12: 45 deg; TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Use Annotation Scale: yes
PSet_Revit_Dimensions - Angle 2: 45 deg; Angle 1: 45 deg
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - Lookup Table Name: M_Wye 45 Deg Double - PVC - Sch 40 - DWV.csv; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - Loss Method: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.60.30.11.14; OmniClass Title: Pipework Fittings
Name (M_Wye 45 Deg Double - PVC - Sch 40 - DWV:Wye 45 Deg Double - PVC - Sch 40 - DWV:Wye 45 Deg Double - PVC - Sch 40 - DWV:...) | In | System Name | Socket Outside Radius = Socket Insulation Outside Radius | Length 7 = Center to Socket Bottom Run Label 1 = Center to Socket Bottom Run | Length 6 | Center to Socket Bottom Branch Label = Length 8 = Center to Socket Bottom Run Label 2 = Center to Socket Bottom Branch | Length 5 | Length 4 = Length 2 | Length 3 = Length 1 | Fitting Outside Radius = Insulation Radius | Wall Thickness | Tick Size | Socket Outside Diameter = Socket Insulation Outside Diameter | Socket Insulation Depth = Socket Depth | Socket Entrance Diameter | Socket Bottom to Socket Bottom Run | Nominal Radius | Nominal Diameter | Fitting Outside Diameter | Size | Mark | Level | Host | Offset (m)
659539 | 1D16 | Sanitary 1 | 0.164917 | 0.135417 | 0.398144 | 0.416667 | 0.178014 | 0.383016 | 0.643433 | 0.145833 | 0.01825 | 0.116667 | 0.329833 | 0.125 | 0.293333 | 0.552083 | 0.131234 | 0.262467 | 0.291667 | 80 mmø-80 mmø-80 mmø-80 mmø | 3821 | Level 2 | Level : Level 2 | -1.6882
655240 | 1B05 | Default Sanitary (cskender) | 0.209167 | 0.15625 | 0.504973 | 0.53125 | 0.227747 | 0.47877 | 0.780854 | 0.1875 | 0.0208333 | 0.15 | 0.418333 | 0.145833 | 0.376667 | 0.6875 | 0.164042 | 0.328084 | 0.375 | 100 mmø-100 mmø-100 mmø-100 mmø | 3416 | Level 2 | Level : Level 2 | -0.411
663911 | 1DC3 | Sanitary 1 | 0.209167 | 0.15625 | 0.504973 | 0.53125 | 0.227747 | 0.47877 | 0.780854 | 0.1875 | 0.0208333 | 0.15 | 0.418333 | 0.145833 | 0.376667 | 0.6875 | 0.164042 | 0.328084 | 0.375 | 100 mmø-100 mmø-100 mmø-100 mmø | 4347 | Level 2 | Level : Level 2 | -1.6882
640709 | TOF Footing | Sanitary 1 | 0.209167 | 0.15625 | 0.504973 | 0.53125 | 0.227747 | 0.47877 | 0.780854 | 0.1875 | 0.0208333 | 0.15 | 0.418333 | 0.145833 | 0.376667 | 0.6875 | 0.164042 | 0.328084 | 0.375 | 100 mmø-100 mmø-100 mmø-100 mmø | 2410 | Level 1 | Level : Level 1 | -0.5
641447 | TOF Footing | Sanitary 1 | 0.209167 | 0.15625 | 0.504973 | 0.53125 | 0.227747 | 0.47877 | 0.780854 | 0.1875 | 0.0208333 | 0.15 | 0.418333 | 0.145833 | 0.376667 | 0.6875 | 0.164042 | 0.328084 | 0.375 | 100 mmø-100 mmø-100 mmø-100 mmø | 2468 | Level 1 | Level : Level 1 | -0.5

# IfcFlowMovingDevice: 150 mm (29)
Type - ElementType: 150 mm; PredefinedType: USERDEFINED
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Supply Air Pressure Drop: 6.06552; System Type: Supply Air
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Air Flow: 15.0087
PSet_Revit_Type_Other - Width 2: 0.127 m; Width 1: 0.0699 m; Half Air Outlet Width: 0.125 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Dimensions - Overall Length: 0.292 m; Supply Air Outlet Width: 0.82021; Supply Air Outlet Height: 0.656168; Supply Air Inlet Radius: 0.246063; Supply Air Inlet Diameter: 0.492126
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.21.24.14; OmniClass Title: Variable Volume Air Terminal Units
Name (M_VAV Unit - Single Duct:150 mm:150 mm:...) | In | System Name | Mark = TagNumber | Level | Host | Offset (m)
569400 | 2A02 | Mechanical Supply Air 2,Default Supply Air (cskender) | C | Level 2 | Level : Level 2 | 3.49048
569911 | 2BC6 | Mechanical Supply Air 2,Default Supply Air (cskender) | SS | Level 2 | Level : Level 2 | 3.24047
568400 | 1D36 | Mechanical Supply Air 1,Default Supply Air (cskender) | JJJ | Level 1 | Level : Level 1 | 3.68048
567920 | 1A07 | Mechanical Supply Air 1,Default Supply Air (cskender) | C | Level 1 | Level : Level 1 | 3.59048
569810 | 2D10 | Mechanical Supply Air 2,Default Supply Air (cskender) | GGG | Level 2 | Level : Level 2 | 3.29048
568425 | 1E25 | Mechanical Supply Air 1,Default Supply Air (cskender) | DDD | Level 1 | Level : Level 1 | 3.68048
567953 | 1A01 | Mechanical Supply Air 1,Default Supply Air (cskender) | A | Level 1 | Level : Level 1 | 3.59048
569609 | 2B19 | Mechanical Supply Air 2,Default Supply Air (cskender) | FF | Level 2 | Level : Level 2 | 3.49047
568139 | 1C15 | Mechanical Supply Air 1,Default Supply Air (cskender) | AA | Level 1 | Level : Level 1 | 3.19048
569822 | 2D07 | Mechanical Supply Air 2,Default Supply Air (cskender) | III | Level 2 | Level : Level 2 | 3.29048
567739 | 1DC8 | Mechanical Supply Air 1,Default Supply Air (cskender) | III | Level 1 | Rectangular Duct : Mitered Elbows / Tees | 3.19047
568123 | 1C18 | Mechanical Supply Air 1,Default Supply Air (cskender) | Z | Level 1 | Level : Level 1 | 3.14047
568301 | 1DC2 | Mechanical Supply Air 1,Default Supply Air (cskender) | O | Level 1 | Level : Level 1 | 3.59048
568096 | 1C19 | Mechanical Supply Air 1,Default Supply Air (cskender) | W | Level 1 | Level : Level 1 | 3.14048
569264 | 2C03 | Mechanical Supply Air 2,Default Supply Air (cskender) | R | Level 2 | Level : Level 2 | 3.49048
569857 | 2B10 | Mechanical Supply Air 2,Default Supply Air (cskender) | QQ | Level 2 | Level : Level 2 | 3.49998
567451 | 1B04 | Mechanical Supply Air 1,Default Supply Air (cskender) | VVV | Level 1 | Level : Level 1 | 3.68047
567738 | 1D35 | Mechanical Supply Air 1,Default Supply Air (cskender) | LL | Level 1 | Level : Level 1 | 3.24047
567740 | 1DC7 | Mechanical Supply Air 1,Default Supply Air (cskender) | KKK | Level 1 | Rectangular Duct : Mitered Elbows / Tees | 3.19048
569677 | 2BC2 | Mechanical Supply Air 2,Default Supply Air (cskender) | LLL | Level 2 | Level : Level 2 | 3.49047
568040 | 1C10 | Mechanical Supply Air 1,Default Supply Air (cskender) | S | Level 1 | Level : Level 1 | 3.59048
568061 | 1C08 | Mechanical Supply Air 1,Default Supply Air (cskender) | V | Level 1 | Level : Level 1 | 3.24048
569856 | 2B8 | Mechanical Supply Air 2,Default Supply Air (cskender) | PP | Level 2 | Level : Level 2 | 3.49047
568031 | 1AC4 | Mechanical Supply Air 1,Default Supply Air (cskender) | J | Level 1 | Level : Level 1 | 3.59048
567418 | 1B19 | Mechanical Supply Air 1,Default Supply Air (cskender) | PPP | Level 1 | Level : Level 1 | 3.68048
567668 | 1E14 | Mechanical Supply Air 1,Default Supply Air (cskender) | NN | Level 1 | Level : Level 1 | 3.18095
567684 | 1E11 | Mechanical Supply Air 1,Default Supply Air (cskender) | VV | Level 1 | Level : Level 1 | 3.68047
567804 | 1D33 | Mechanical Supply Air 1,Default Supply Air (cskender) | XX | Level 1 | Level : Level 1 | 3.19998
567803 | 1D31 | Mechanical Supply Air 1,Default Supply Air (cskender) | WW | Level 1 | Level : Level 1 | 3.19998

# IfcFlowMovingDevice: 200 mm (47)
Type - ElementType: 200 mm; PredefinedType: USERDEFINED
PSet_Revit_Mechanical - Supply Air Pressure Drop: 6.06552; System Type: Supply Air
PSet_Revit_Mechanical - Airflow - Air Flow: 15.0087
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.21.24.14; OmniClass Title: Variable Volume Air Terminal Units
PSet_Revit_Type_Other - Width 2: 0.1397 m; Width 1: 0.0572 m; Half Air Outlet Width: 0.1375 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Dimensions - Overall Length: 0.279 m; Supply Air Outlet Width: 0.902231; Supply Air Outlet Height: 0.82021; Supply Air Inlet Radius: 0.328084; Supply Air Inlet Diameter: 0.656168
Name (M_VAV Unit - Single Duct:200 mm:200 mm:...) | In | Level | Host | Offset (m) | System Name | Mark = TagNumber
569203 | 2C13 | Level 2 | Level : Level 2 | 3.26547 | Mechanical Supply Air 2,Default Supply Air (cskender) | Y
569732 | 2D18 | Level 2 | Level : Level 2 | 3.4655 | Mechanical Supply Air 2,Default Supply Air (cskender) | DDD
569787 | 2D16 | Level 2 | Level : Level 2 | 3.4655 | Mechanical Supply Air 2,Default Supply Air (cskender) | AAA
568242 | 1D13 | Level 1 | Level : Level 1 | 3.3655 | Mechanical Supply Air 1,Default Supply Air (cskender) | EE
568371 | 1E06 | Level 1 | Level : Level 1 | 3.65548 | Mechanical Supply Air 1,Default Supply Air (cskender) | CCC
567378 | 1E04 | Level 1 | Level : Level 1 | 3.1655 | Mechanical Supply Air 1,Default Supply Air (cskender) | EEE
567304 | 1E07 | Level 1 | Level : Level 1 | 3.36548 | Mechanical Supply Air 1,Default Supply Air (cskender) | AAA
569794 | 2D18 | Level 2 | Level : Level 2 | 3.26548 | Mechanical Supply Air 2,Default Supply Air (cskender) | JJJ
569255 | 2C09 | Level 2 | Level : Level 2 | 3.36545 | Mechanical Supply Air 2,Default Supply Air (cskender) | U
568225 | 1D16 | Level 1 | Level : Level 1 | 3.16548 | Mechanical Supply Air 1,Default Supply Air (cskender) | II
568161 | 1C01 | Level 1 | Level : Level 1 | 3.56548 | Mechanical Supply Air 1,Default Supply Air (cskender) | CC
569401 | 2A03 | Level 2 | Level : Level 2 | 3.4655 | Mechanical Supply Air 2,Default Supply Air (cskender) | D
569404 | 2A06 | Level 2 | Level : Level 2 | 3.4655 | Mechanical Supply Air 2,Default Supply Air (cskender) | H
569532 | 2B21 | Level 2 | Level : Level 2 | 3.4655 | Mechanical Supply Air 2,Default Supply Air (cskender) | DD
569837 | 2B01 | Level 2 | Level : Level 2 | 3.4655 | Mechanical Supply Air 2,Default Supply Air (cskender) | LL
567340 | 1EC1 | Level 1 | Level : Level 1 | 3.65548 | Mechanical Supply Air 1,Default Supply Air (cskender) | OOO
567935 | 1A05 | Level 1 | Level : Level 1 | 3.56548 | Mechanical Supply Air 1,Default Supply Air (cskender) | F
569707 | 2DC2 | Level 2 | Level : Level 2 | 3.4655 | Mechanical Supply Air 2,Default Supply Air (cskender) | VV
568113 | 1C18 | Level 1 | Level : Level 1 | 3.11547 | Mechanical Supply Air 1,Default Supply Air (cskender) | Y
568072 | 1C09 | Level 1 | Level : Level 1 | 3.16548 | Mechanical Supply Air 1,Default Supply Air (cskender) | T
568226 | 1D21 | Level 1 | Level : Level 1 | 3.06548 | Mechanical Supply Air 1,Default Supply Air (cskender) | HH
567770 | 1D34 | Level 1 | Level : Level 1 | 3.1655 | Mechanical Supply Air 1,Default Supply Air (cskender) | YY
569836 | 2B3 | Level 2 | Level : Level 2 | 3.4655 | Mechanical Supply Air 2,Default Supply Air (cskender) | MM
567493 | 1BC2 | Level 1 | Level : Level 1 | 3.2259 | Mechanical Supply Air 1,Default Supply Air (cskender) | WWW
569809 | 2D10 | Level 2 | Level : Level 2 | 3.26548 | Mechanical Supply Air 2,Default Supply Air (cskender) | FFF
569265 | 2C19 | Level 2 | Level : Level 2 | 3.10595 | Mechanical Supply Air 2,Default Supply Air (cskender) | V
569403 | 2A05 | Level 2 | Level : Level 2 | 3.4655 | Mechanical Supply Air 2,Default Supply Air (cskender) | F
568277 | 1D10 | Level 1 | Level : Level 1 | 3.56548 | Mechanical Supply Air 1,Default Supply Air (cskender) | R
568130 | 1C18 | Level 1 | Level : Level 1 | 3.16548 | Mechanical Supply Air 1,Default Supply Air (cskender) | BB
567491 | 1B17 | Level 1 | Level : Level 1 | 3.3559 | Mechanical Supply Air 1,Default Supply Air (cskender) | RRR
569408 | 2A08 | Level 2 | Level : Level 2 | 3.406 | Mechanical Supply Air 2,Default Supply Air (cskender) | K
568287 | 1D07 | Level 1 | Level : Level 1 | 3.56548 | Mechanical Supply Air 1,Default Supply Air (cskender) | Q
569406 | 2A07 | Level 2 | Level : Level 2 | 3.436 | Mechanical Supply Air 2,Default Supply Air (cskender) | I
568320 | Level 1 | Level 1 | Level : Level 1 | 3.56548 | Mechanical Supply Air 1,Default Supply Air (cskender) | M
569808 | 2D11 | Level 2 | Level : Level 2 | 3.26548 | Mechanical Supply Air 2,Default Supply Air (cskender) | EEE
567927 | 1A06 | Level 1 | Level : Level 1 | 3.175 | Mechanical Supply Air 1,Default Supply Air (cskender) | D
569608 | 2B19 | Level 2 | Level : Level 2 | 3.4655 | Mechanical Supply Air 2,Default Supply Air (cskender) | GG
569409 | 2A09 | Level 2 | Level : Level 2 | 3.3655 | Mechanical Supply Air 2,Default Supply Air (cskender) | M
567859 | 1E23 | Level 1 | Level : Level 1 | 3.26547 | Mechanical Supply Air 1,Default Supply Air (cskender) | TT
567408 | 1E27 | Level 1 | Level : Level 1 | 3.3655 | Mechanical Supply Air 1,Default Supply Air (cskender) | GGG
569402 | 2A05 | Level 2 | Level : Level 2 | 3.4655 | Mechanical Supply Air 2,Default Supply Air (cskender) | E
569258 | 2C02 | Level 2 | Level : Level 2 | 3.36545 | Mechanical Supply Air 2,Default Supply Air (cskender) | O
569257 | 2C04 | Level 2 | Level : Level 2 | 3.36547 | Mechanical Supply Air 2,Default Supply Air (cskender) | Q
567655 | 1D23 | Level 1 | Level : Level 1 | 3.06548 | Mechanical Supply Air 1,Default Supply Air (cskender) | MM
569256 | 2C06 | Level 2 | Level : Level 2 | 3.36545 | Mechanical Supply Air 2,Default Supply Air (cskender) | S
567667 | 1E33 | Level 1 | Level : Level 1 | 3.15595 | Mechanical Supply Air 1,Default Supply Air (cskender) | PP
567643 | 1D24 | Level 1 | Level : Level 1 | 3.12593 | Mechanical Supply Air 1,Default Supply Air (cskender) | LL

# IfcFlowMovingDevice: 250 mm (42)
Type - ElementType: 250 mm; PredefinedType: USERDEFINED
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Supply Air Pressure Drop: 6.06552; System Type: Supply Air
PSet_Revit_Mechanical - Airflow - Air Flow: 15.0087
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Dimensions - Overall Length: 0.305 m; Supply Air Outlet Width: 1.14829; Supply Air Outlet Height: 0.984252; Supply Air Inlet Radius: 0.410105; Supply Air Inlet Diameter: 0.82021
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.21.24.14; OmniClass Title: Variable Volume Air Terminal Units
PSet_Revit_Type_Other - Width 2: 0.127 m; Width 1: 0.0699 m; Half Air Outlet Width: 0.175 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_VAV Unit - Single Duct:250 mm:250 mm:...) | In | TagNumber = Mark | System Name | Level | Host | Offset (m)
569187 | 2C14 | BB | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.4405
569182 | 2C16 | Z | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.24048
569398 | 2A01 | A | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.44048
569781 | 2D14 | BBB | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.44048
569755 | 2D21 | WW | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.44047
569858 | 2B11 | RR | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.44048
568241 | 1DC4 | KK | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.34048
568150 | 1D16 | DD | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.14048
567976 | 1AC5 | G1 | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.54048
567982 | 1A16 | I | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.54048
568327 | 1D06 | N | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.54048
569399 | 2A14 | B | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.44048
568300 | 1DC2 | P | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.54048
569767 | 2D17 | ZZ | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.44048
569261 | 2CC1 | T | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.44048
568209 | 1D22 | GG | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.04048
569407 | 2A11 | J | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.44048
567492 | 1B13 | SSS | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.63047
569230 | 2C12 | CC | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.24048
569477 | 2AC2 | L | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.4405
569259 | 2C01 | N | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.44048
568059 | 1C04 | U | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Rectangular Duct : Mitered Elbows / Taps | 3.19048
569262 | 2C10 | W | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.44048
567965 | 1A02 | B | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.54048
569855 | 2B7 | OO | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.44048
567427 | 1B19 | UUU | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.62095
567707 | 1BC4 | MMM | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.2509
567558 | 1B04 | ZZZ | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.63048
569671 | 2BC2 | KK | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.44048
567717 | 1BC4 | NNN | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.53047
569689 | 2D01 | TT | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.44048
569663 | 2B18 | II | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.44048
569607 | 2BC4 | EE | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.44047
569260 | 2C03 | P | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.44048
568097 | 1C14 | X | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.14048
569263 | 2C19 | X | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.13095
567557 | 1BC1 | YYY | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.63048
567831 | 1E16 | RR | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.24048
569643 | 2B15 | JJ | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.44047
568021 | 1AC3 | K | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.5655
567621 | 1D25 | UU | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.12145
568006 | 1A16 | H | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.54048

# IfcFlowMovingDevice: 3.9 LPS - 0.8 Meter Head, M_Inline Pump - Circulator:3.9 LPS - 0.8 Meter Head:3.9 LPS - 0.8 Meter Head:1060890
In: 1D18
Type - ElementType: 3.9 LPS - 0.8 Meter Head; PredefinedType: CIRCULATOR
PSet_Revit_Type_Other - Radius 3: 0.056432 m; Radius 2: 0.0728 m; Radius 1: 0.07915 m; Outside Radius 4: 0.031032 m; Outside Radius 2: 0.0855 m; Outside Radius 1: 0.092 m; Length 4: 0.0213482 m; Flange Radius: 0.051 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Electrical - Loads - Apparent Load: 5834.04
PSet_Revit_Type_Dimensions - Suction Outside Radius: 0.086122; Suction Outside Diameter: 0.172244; Suction Nominal Radius: 0.0656168; Suction Nominal Diameter: 0.131234; Outside Diameter 4: 0.062064 m; Outside Diameter 2: 0.171 m; Outside Diameter 1: 0.184 m; Length 3: 0.062064 m; Length 2: 0.3448 m; Length 1: 0.431 m; Housing Width: 0.152 m; Flange Height: 0.13 m; Flange Diameter: 0.102 m; Discharge Nominal Radius: 0.0656168; Discharge Nominal Diameter: 0.131234
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: HWP-1; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.60.30.21; OmniClass Title: Pumps
PSet_Revit_Identity Data - Mark: HWP-1
PSet_Revit_Type_Electrical - Voltage: 4951.4; Number of Poles: 3; Load Classification: Appliance - Dwelling Unit
PSet_Revit_Electrical - Loads - Panel: MS1; Circuit Number: 2
PSet_Revit_Mechanical - RPM: 1450; System Type: Domestic Hot Water,Power; System Name: Domestic Hot Water 1
PSet_Revit_Constraints - Level: Level 2; Host: Level : Level 2; Offset: -1.4 m

# IfcFlowMovingDevice: 300 mm (9)
Type - ElementType: 300 mm; PredefinedType: USERDEFINED
PSet_Revit_Mechanical - Supply Air Pressure Drop: 6.06552; System Type: Supply Air
PSet_Revit_Mechanical - Airflow - Air Flow: 15.0087
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.21.24.14; OmniClass Title: Variable Volume Air Terminal Units
PSet_Revit_Type_Dimensions - Overall Length: 0.33 m; Supply Air Outlet Width: 1.39436; Supply Air Outlet Height: 1.14829; Supply Air Inlet Radius: 0.492126; Supply Air Inlet Diameter: 0.984252
PSet_Revit_Type_Other - Width 2: 0.1143 m; Width 1: 0.0826 m; Half Air Outlet Width: 0.2125 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_VAV Unit - Single Duct:300 mm:300 mm:...) | In | System Name | Level | Host | Offset (m) | TagNumber = Mark
568348 | 1D02 | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Rectangular Duct : Mitered Elbows / Tees | 3.53505 | L
569405 | 2A12 | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.41548 | G
568188 | 1DC1 | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Rectangular Duct : Mitered Elbows / Tees | 3.01547 | FF
569759 | 2D20 | Mechanical Supply Air 2,Default Supply Air (cskender) | Level 2 | Level : Level 2 | 3.41547 | XX
567471 | 1B19 | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.5055 | QQQ
567587 | 1D25 | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.09645 | OO
567386 | 1EC2 | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.60548 | FFF
567830 | 1E16 | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.21548 | QQ
567727 | 1DC8 | Mechanical Supply Air 1,Default Supply Air (cskender) | Level 1 | Level : Level 1 | 3.11547 | HH

# IfcFlowMovingDevice: 350 mm (5)
Type - ElementType: 350 mm; PredefinedType: USERDEFINED
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Air Flow: 15.0087
PSet_Revit_Mechanical - Supply Air Pressure Drop: 6.06552; System Type: Supply Air
PSet_Revit_Type_Dimensions - Overall Length: 0.356 m; Supply Air Outlet Width: 1.5584; Supply Air Outlet Height: 1.47638; Supply Air Inlet Radius: 0.574147; Supply Air Inlet Diameter: 1.14829
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.21.24.14; OmniClass Title: Variable Volume Air Terminal Units
PSet_Revit_Type_Other - Width 2: 0.1143 m; Width 1: 0.0826 m; Half Air Outlet Width: 0.2375 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_VAV Unit - Single Duct:350 mm:350 mm:...) | In | Mark = TagNumber | Level | Host | Offset (m) | System Name
567902 | 1A16 | G2 | Level 1 | Level : Level 1 | 3.46548 | Mechanical Supply Air 1,Default Supply Air (cskender)
567318 | 1EC1 | BBB | Level 1 | Level : Level 1 | 3.55548 | Mechanical Supply Air 1,Default Supply Air (cskender)
569217 | 2C17 | AA | Level 2 | Level : Level 2 | 3.16548 | Mechanical Supply Air 2,Default Supply Air (cskender)
567577 | 1BC2 | TTT | Level 1 | Level : Level 1 | 3.4555 | Mechanical Supply Air 1,Default Supply Air (cskender)
569690 | 2D04-A | UU | Level 2 | Level : Level 2 | 3.36545 | Mechanical Supply Air 2,Default Supply Air (cskender)

# IfcFlowMovingDevice: 400 mm, M_VAV Unit - Single Duct:400 mm:400 mm:567458
In: 1B04
Type - ElementType: 400 mm; PredefinedType: USERDEFINED
PSet_Revit_Type_Other - Width 2: 0.0889 m; Width 1: 0.108 m; Half Air Outlet Width: 0.2875 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Dimensions - Overall Length: 0.381 m; Supply Air Outlet Width: 1.88648; Supply Air Outlet Height: 1.47638; Supply Air Inlet Radius: 0.656168; Supply Air Inlet Diameter: 1.31234
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.21.24.14; OmniClass Title: Variable Volume Air Terminal Units
PSet_Revit_Other - TagNumber: XXX; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: XXX
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Level: Level 1; Host: Level : Level 1; Offset: 3.45547 m
PSet_Revit_Mechanical - Airflow - Air Flow: 15.0087
PSet_Revit_Mechanical - Supply Air Pressure Drop: 6.06552; System Type: Supply Air; System Name: Mechanical Supply Air 1,Default Supply Air (cskender)

# IfcFlowMovingDevice: 63300000 J (2)
In: 2D05
Type - ElementType: 63300000 J; PredefinedType: CENTRIFUGALAIRFOIL
PSet_Revit_Mechanical - External Static Pressure: 37.7952; System Type: Power,Hydronic Return,Hydronic Supply,Return Air,Supply Air
PSet_Revit_Constraints - Level: Level 2; Host: Level : Level 2; Offset: 0 m
PSet_Revit_Mechanical - Airflow - Supply Airflow: 12.7486; Return Airflow: 12.7486
PSet_Revit_Electrical - Loads - Circuit Number: 1,3,5
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Electrical - Voltage: 2238.89; Load Classification: Cooling; Poles: 3
PSet_Revit_Type_Dimensions - Width: 3.175 m; Length: 6.846 m; Height: 1.8 m; Dimension H: 6.151 m; Dimension G: 0.695 m; Dimension F: 2.9 m; Dimension E: 1.5 m; Dimension D: 1.5 m; Dimension A: 9.51444; Condensate Radius: 0.164042; Condensate Diameter: 0.328084
PSet_Revit_Type_Electrical - Loads - Apparent Load: 11194.5
PSet_Revit_Type_Energy Analysis - Heating Capacity: 653000279; Cooling Capacity: 607574176
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; Type Mark: 1; OmniClass Number: 23.75.35.14.17; OmniClass Title: Modular Indoor Air Handling Units
Name (M_Air Handling Unit - Split System - Horizontal:63300000 J:63300000 J:...) | System Name | Mark = TagNumber | Panel
570459 | Hydronic Return 1,Hydronic Supply 1,Mechanical Return Air 2,Mechanical Supply Air 2 | AHU-2 | 2MEC
570439 | Hydronic Return 1,Hydronic Supply 1,Mechanical Return Air 1,Mechanical Supply Air 1 | AHU-1 | 1MEC

# IfcFlowMovingDevice: 991-1905 LPS, M_Centrifugal Fan - Rooftop - Upblast:991-1905 LPS:991-1905 LPS:1062388
In: 3R01
Type - ElementType: 991-1905 LPS; PredefinedType: CENTRIFUGALAIRFOIL
PSet_Revit_Type_Mechanical - RPM: 1564
PSet_Revit_Type_Electrical - Voltage: 4951.4; Load Classification: Cooling; Number of Poles: 3
PSet_Revit_Type_Dimensions - Overall Height: 0.635 m; Fan Radius: 0.373 m; Fan Height: 0.489 m; Fan Diameter: 0.746 m; Outlet Width: 1.47638; Outlet Height: 1.47638; Cap Radius: 0.2611 m; Cap Diameter: 0.5222 m; Base Width: 0.746 m
PSet_Revit_Mechanical - External Static Presure: 37.7952; System Type: Exhaust Air,Power; System Name: Mechanical Exhaust Air 1
PSet_Revit_Type_Constraints - Default Elevation: 1.2 m
PSet_Revit_Type_Electrical - Loads - Apparent Load: 10118.1
PSet_Revit_Constraints - Host: Level : Roof - Main; Elevation: 0 m
PSet_Revit_Type_Other - Radius 1: 0.3302 m; Radius 2: 0.2984 m; Half Outlet Radius: 0.225 m; Half Exhaust Inlet Height: 0.225 m; Diameter 2: 0.5968 m; Diameter 1: 0.6604 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Electrical - Loads - Panel: MS1; Circuit Number: 1
PSet_Revit_Identity Data - Mark: RAF-1
PSet_Revit_Mechanical - Airflow - Air Flow: 67.2744
PSet_Revit_Other - Schedule Level: Roof - Main; TagNumber: RAF-1; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.35.17.27; OmniClass Title: Centrifugal Fans

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1106779
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1106779
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.701412 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.0941233; Hydraulic Diameter: 0.492126; Section: 54; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Identity Data - Mark: 54
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 3.05066; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1107115
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1107115
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.181553; Hydraulic Diameter: 0.656168; Section: 173; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.79671 m
PSet_Revit_Identity Data - Mark: 55
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.86186; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1107872
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1107872
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.154899; Hydraulic Diameter: 0.492126; Section: 97; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 89
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.15432 m
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 5.02049; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:1108447
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:1108447
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.229534; Hydraulic Diameter: 0.492126; Section: 371; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 7.4395; Velocity Pressure: 32.4113; Reynolds number: 132913
