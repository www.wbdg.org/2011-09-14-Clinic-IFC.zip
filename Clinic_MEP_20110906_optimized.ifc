Properties of the parts of a building model (IFC2X3), part 37 of 295

# IfcFlowFitting: Transition - Generic (1536)
Name (M_Transition - Generic:Transition - Generic:Transition - Generic:...) | In | Mark | System Type | System Name | Width Offset | Visibility 3 | Visibility 2 | Visibility 1 | Max Fitting Outside Diameter 12 | Height Offset | Fitting Outside Radius 2 = Insulation Radius 2 | Fitting Outside Radius 1 = Insulation Radius 1 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level | Host | Offset (m) | Tick Size 2 | Tick Size 1 | Nominal Radius 2 | Nominal Radius 1 | Nominal Diameter 2 | Nominal Diameter 1 | Length | Fitting Outside Diameter 2 | Fitting Outside Diameter 1 | Size | OffsetHeight | OffsetWidth
664529 | Level 2 | 4446 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.5 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
655498 | 1B05 | 3441 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.34375 | 10 | 0.0677083 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -0.345912 | 0.0541667 | 0.1375 | 0.0656168 | 0.164042 | 0.131234 | 0.328084 | 0.0859375 | 0.135417 | 0.34375 | 100 mmø-40 mmø | 0.164042 | 0.164042
678339 | TOF Footing | 4944 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.114583 | 10 | 0.0364583 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0458333 | 0.0328084 | 0.0524934 | 0.0656168 | 0.104987 | 0.0286458 | 0.0729167 | 0.114583 | 32 mmø-20 mmø | 0.0524934 | 0.0524934
678529 | TOF Footing | 4957 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.0677083 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0541667 | 0.0875 | 0.0656168 | 0.106627 | 0.131234 | 0.213255 | 0.0546875 | 0.135417 | 0.21875 | 65 mmø-40 mmø | 0.106627 | 0.106627
655505 | 1B05 | 3447 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -0.2 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
679413 | TOF Footing | 5036 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
645817 | TOF Footing | 2961 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.260417 | 10 | 0.0572917 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.447612 | 0.0458333 | 0.104167 | 0.0524934 | 0.131234 | 0.104987 | 0.262467 | 0.0651042 | 0.114583 | 0.260417 | 80 mmø-32 mmø | 0.131234 | 0.131234
1029524 | 2AC2 | 11760 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
1043060 | 2BC2 | 11906 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
679188 | TOF Footing | 5003 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.0260417 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0875 | 0.0246063 | 0.106627 | 0.0492126 | 0.213255 | 0.0546875 | 0.0520833 | 0.21875 | 65 mmø-15 mmø | 0.106627 | 0.106627
685694 | TOF Footing | 5713 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.0885417 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0708333 | 0.0875 | 0.082021 | 0.106627 | 0.164042 | 0.213255 | 0.0546875 | 0.177083 | 0.21875 | 65 mmø-50 mmø | 0.106627 | 0.106627
677965 | TOF Footing | 4919 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
680980 | TOF Footing | 5183 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
679161 | TOF Footing | 4996 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
646388 | TOF Footing | 3065 | Sanitary | Sanitary 1 | 9.98432 | no | yes | no | 0.177083 | 10.0169 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.461397 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.0988999 | 0.0663448
667042 | 1DC3 | 4727 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.50761 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
678991 | TOF Footing | 4979 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0375 | 0.0708333 | 0.0410105 | 0.082021 | 0.082021 | 0.164042 | 0.0442708 | 0.09375 | 0.177083 | 50 mmø-25 mmø | 0.082021 | 0.082021
680979 | TOF Footing | 5182 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
678341 | TOF Footing | 4945 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.114583 | 10 | 0.0364583 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0458333 | 0.0328084 | 0.0524934 | 0.0656168 | 0.104987 | 0.0286458 | 0.0729167 | 0.114583 | 32 mmø-20 mmø | 0.0524934 | 0.0524934
678461 | TOF Footing | 4952 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0364583 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0375 | 0.0328084 | 0.0410105 | 0.0656168 | 0.082021 | 0.0234375 | 0.0729167 | 0.09375 | 25 mmø-20 mmø | 0.0410105 | 0.0410105
1028562 | 1D04 | 11661 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
660242 | 1D16 | 3892 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
1028544 | 1A12 | 11657 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.01 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0756163 | 0.0656168
685671 | TOF Footing | 5706 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.34375 | 10 | 0.109375 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0875 | 0.1375 | 0.106627 | 0.164042 | 0.213255 | 0.328084 | 0.0859375 | 0.21875 | 0.34375 | 100 mmø-65 mmø | 0.164042 | 0.164042
660047 | Level 2 | 3879 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 3.1 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
691436 | TOF Footing | 6436 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0375 | 0.0708333 | 0.0410105 | 0.082021 | 0.082021 | 0.164042 | 0.0442708 | 0.09375 | 0.177083 | 50 mmø-25 mmø | 0.082021 | 0.082021
1027680 | 1AC5 | 11472 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1047526 | 2C13 | 11931 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0053 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0708899 | 0.0656168
664552 | Level 2 | 4450 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.85952 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
645957 | TOF Footing | 2996 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.460312 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
1027640 | 1A16 | 11464 | Fire Protection Wet | Fire Protection | 9.96548 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.031101
681235 | TOF Footing | 5197 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.34375 | 10 | 0.130208 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.104167 | 0.1375 | 0.131234 | 0.164042 | 0.262467 | 0.328084 | 0.0859375 | 0.260417 | 0.34375 | 100 mmø-80 mmø | 0.164042 | 0.164042
664336 | Level 1 | 4410 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
662371 | 2A09 | 4201 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.177083 | 10 | 0.0885417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 7.47 | 0.0708333 | 0.0458333 | 0.082021 | 0.0524934 | 0.164042 | 0.104987 | 0.0442708 | 0.177083 | 0.114583 | 50 mmø-32 mmø | 0.0524934 | 0.0524934
688998 | TOF Footing | 6126 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
659729 | 1D16 | 3833 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.260417 | 10 | 0.0885417 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.0708333 | 0.104167 | 0.082021 | 0.131234 | 0.164042 | 0.262467 | 0.0651042 | 0.177083 | 0.260417 | 80 mmø-50 mmø | 0.131234 | 0.131234
681233 | TOF Footing | 5196 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.34375 | 10 | 0.130208 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.104167 | 0.1375 | 0.131234 | 0.164042 | 0.262467 | 0.328084 | 0.0859375 | 0.260417 | 0.34375 | 100 mmø-80 mmø | 0.164042 | 0.164042
631202 | TOF Footing | 1083 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.2 | 0.0375 | 0.0708333 | 0.082021 | 0.0524934 | 0.082021 | 0.104987 | 0.0442708 | 0.09375 | 0.177083 | 50 mmø-32 mmø | 0.0524934 | 0.0524934
1049962 | 2D19 | 12480 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
693702 | 1E33 | 6634 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
660020 | Level 2 | 3870 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 3 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
1048119 | 2C12 | 12036 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
677966 | TOF Footing | 4920 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
646922 | TOF Footing | 3136 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
631339 | TOF Footing | 1108 | Sanitary |  | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0375 | 0.0708333 | 0.082021 | 0.0524934 | 0.082021 | 0.104987 | 0.0442708 | 0.09375 | 0.177083 | 50 mmø-32 mmø | 0.0524934 | 0.0524934
646433 | TOF Footing | 3081 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.461436 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
691191 | TOF Footing | 6397 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
679026 | TOF Footing | 4987 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
655107 | Level 1 | 3396 | Sanitary | Default Sanitary (cskender) | 10 | yes | no | no | 0.34375 | 10 | 0.171875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0 | 0.1375 | 0.0708333 | 0.164042 | 0.082021 | 0.328084 | 0.164042 | 0.0859375 | 0.34375 | 0.177083 | 100 mmø-50 mmø | 0.082021 | 0.082021
687893 | TOF Footing | 5976 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
662928 | 2AC3 | 4273 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.135417 | 10 | 0.0677083 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.9 | 0.0541667 | 0.0458333 | 0.0656168 | 0.0524934 | 0.131234 | 0.104987 | 0.0338542 | 0.135417 | 0.114583 | 40 mmø-32 mmø | 0.0524934 | 0.0524934
657104 | 1B04 | 3599 | Sanitary | Default Sanitary (cskender) | 10 | yes | no | no | 0.260417 | 10 | 0.130208 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6822 | 0.104167 | 0.0708333 | 0.131234 | 0.082021 | 0.262467 | 0.164042 | 0.0651042 | 0.260417 | 0.177083 | 80 mmø-50 mmø | 0.082021 | 0.082021
654328 | 1B11 | 3351 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.34375 | 10 | 0.130208 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -0.411 | 0.104167 | 0.1375 | 0.131234 | 0.164042 | 0.262467 | 0.328084 | 0.0859375 | 0.260417 | 0.34375 | 100 mmø-80 mmø | 0.164042 | 0.164042
690169 | TOF Footing | 6259 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
680186 | TOF Footing | 5111 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
1050641 | 2D18 | 12676 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
681673 | TOF Footing | 5268 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.0260417 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0875 | 0.0246063 | 0.106627 | 0.0492126 | 0.213255 | 0.0546875 | 0.0520833 | 0.21875 | 65 mmø-15 mmø | 0.106627 | 0.106627
1029505 | 2AC2 | 11756 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
690484 | TOF Footing | 6290 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
688999 | TOF Footing | 6127 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
666136 | Level 2 | 4590 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.239688 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
666809 | 1DC3 | 4697 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.130208 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.56 | 0.104167 | 0.1375 | 0.131234 | 0.164042 | 0.262467 | 0.328084 | 0.0859375 | 0.260417 | 0.34375 | 100 mmø-80 mmø | 0.164042 | 0.164042
687762 | TOF Footing | 5961 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.0364583 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0875 | 0.0328084 | 0.106627 | 0.0656168 | 0.213255 | 0.0546875 | 0.0729167 | 0.21875 | 65 mmø-20 mmø | 0.106627 | 0.106627
654014 | 1B04 | 3312 | Sanitary | Default Sanitary (cskender) | 10 | yes | no | no | 0.135417 | 10 | 0.0677083 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -0.411 | 0.0541667 | 0.0458333 | 0.0656168 | 0.0524934 | 0.131234 | 0.104987 | 0.0338542 | 0.135417 | 0.114583 | 40 mmø-32 mmø | 0.0524934 | 0.0524934
708622 | TOF Footing | 8411 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
645545 | TOF Footing | 2919 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.461436 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
653716 | 1B08 | 3292 | Undefined | Default Sanitary (cskender) | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -0.373694 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
1047511 | 2C14 | 11923 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0053 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0708899 | 0.0656168
1053277 | 2A13 | 13370 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1048358 | 2CC1 | 12092 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
647821 | 1C04 | 3236 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.135417 | 10 | 0.0677083 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0 | 0.0541667 | 0.0458333 | 0.0656168 | 0.0524934 | 0.131234 | 0.104987 | 0.0338542 | 0.135417 | 0.114583 | 40 mmø-32 mmø | 0.0524934 | 0.0524934
655610 | 1B07 | 3471 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -0.2 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
1027015 | 1B06 | 11272 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1026995 | 1B08 | 11268 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 9.98908 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0546966 | 0.0656168
1027580 | 1A14 | 11444 | Fire Protection Wet | Fire Protection | 9.9995 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.065112
678558 | TOF Footing | 4959 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
665093 | Level 2 | 4503 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0677083 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.29802 | 0.0541667 | 0.1375 | 0.0656168 | 0.164042 | 0.131234 | 0.328084 | 0.0859375 | 0.135417 | 0.34375 | 100 mmø-40 mmø | 0.164042 | 0.164042
1029177 | Level 2 | 11736 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
1047990 | 2C07 | 12004 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1027431 | 1B03 | 11396 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
667467 | Level 2 | 4782 | Sanitary | Sanitary 1 | 10.0448 | no | no | yes | 0.135417 | 10 | 0.0677083 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.9 | 0.0541667 | 0.0541667 | 0.0656168 | 0.0656168 | 0.131234 | 0.131234 | 0.0338542 | 0.135417 | 0.135417 | 40 mmø-40 mmø | 0.0656168 | 0.110386
704119 | TOF Footing | 7851 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1001453 | 1BC4 | 10153 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
645741 | TOF Footing | 2946 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.501123 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
646534 | TOF Footing | 3099 | Undefined | Sanitary 1 | 10.0007 | no | yes | no | 0.260417 | 9.95929 | 0.0885417 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.448736 | 0.0708333 | 0.104167 | 0.082021 | 0.131234 | 0.164042 | 0.262467 | 0.0651042 | 0.177083 | 0.260417 | 80 mmø-50 mmø | 0.090528 | 0.131944
686875 | TOF Footing | 5853 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.0260417 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0875 | 0.0246063 | 0.106627 | 0.0492126 | 0.213255 | 0.0546875 | 0.0520833 | 0.21875 | 65 mmø-15 mmø | 0.106627 | 0.106627
1048095 | 2C10 | 12028 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
684543 | Level 1 | 5563 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.786419 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
1048880 | 2C22 | 12156 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
667326 | Level 2 | 4764 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0677083 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.29802 | 0.0541667 | 0.1375 | 0.0656168 | 0.164042 | 0.131234 | 0.328084 | 0.0859375 | 0.135417 | 0.34375 | 100 mmø-40 mmø | 0.164042 | 0.164042
1030799 | 2D05 | 11864 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
666842 | 1DC3 | 4708 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.260417 | 10 | 0.130208 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.56 | 0.104167 | 0.0375 | 0.131234 | 0.0410105 | 0.262467 | 0.082021 | 0.0651042 | 0.260417 | 0.09375 | 80 mmø-25 mmø | 0.0410105 | 0.0410105
683565 | TOF Footing | 5439 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0677083 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0541667 | 0.1375 | 0.0656168 | 0.164042 | 0.131234 | 0.328084 | 0.0859375 | 0.135417 | 0.34375 | 100 mmø-40 mmø | 0.164042 | 0.164042
708650 | 1DC3 | 8417 | Undefined |  | 10 | no | yes | no | 0.34375 | 10 | 0.0260417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.75329 | 0.0208333 | 0.1375 | 0.0246063 | 0.164042 | 0.0492126 | 0.328084 | 0.0859375 | 0.0520833 | 0.34375 | 100 mmø-15 mmø | 0.164042 | 0.164042
625373 | TOF Footing | 375 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.177083 | 10 | 0.0885417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0708333 | 0.0458333 | 0.082021 | 0.0524934 | 0.164042 | 0.104987 | 0.0442708 | 0.177083 | 0.114583 | 50 mmø-32 mmø | 0.0524934 | 0.0524934
666200 | TOF Footing | 4606 | Sanitary | Sanitary 1 | 10 | no | no | yes | 0.34375 | 10.0037 | 0.171875 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.501123 | 0.1375 | 0.1375 | 0.164042 | 0.164042 | 0.328084 | 0.328084 | 0.0859375 | 0.34375 | 0.34375 | 100 mmø-100 mmø | 0.167728 | 0.164042
692167 | Level 2 | 6463 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.2 | 0.0375 | 0.0708333 | 0.0410105 | 0.082021 | 0.082021 | 0.164042 | 0.0442708 | 0.09375 | 0.177083 | 50 mmø-25 mmø | 0.082021 | 0.082021
1050592 | 2D21 | 12664 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
694022 | 1C07 | 6643 | Domestic Cold Water | Domestic Cold Water 1 | 10 | yes | no | no | 0.114583 | 10 | 0.0572917 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0458333 | 0.0375 | 0.0524934 | 0.0410105 | 0.104987 | 0.082021 | 0.0286458 | 0.114583 | 0.09375 | 32 mmø-25 mmø | 0.0410105 | 0.0410105
688483 | TOF Footing | 6059 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
661640 | 1CC1 | 4088 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.260417 | 10 | 0.0885417 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.63581 | 0.0708333 | 0.104167 | 0.082021 | 0.131234 | 0.164042 | 0.262467 | 0.0651042 | 0.177083 | 0.260417 | 80 mmø-50 mmø | 0.131234 | 0.131234
1049010 | 2D05 | 12208 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1060905 | 1D18 | 13436 | Domestic Hot Water | Domestic Hot Water 1 | 10 | yes | no | no | 0.21875 | 10 | 0.109375 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0875 | 0.0541667 | 0.106627 | 0.0656168 | 0.213255 | 0.131234 | 0.0546875 | 0.21875 | 0.135417 | 65 mmø-40 mmø | 0.0656168 | 0.0656168
695218 | 1C10 | 6786 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
678405 | TOF Footing | 4947 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
684584 | TOF Footing | 5570 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
667507 | 1D01 | 4789 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0677083 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.49491 | 0.0541667 | 0.1375 | 0.0656168 | 0.164042 | 0.131234 | 0.328084 | 0.0859375 | 0.135417 | 0.34375 | 100 mmø-40 mmø | 0.164042 | 0.164042
1029691 | 2BC2 | 11779 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
1027609 | 1A13 | 11448 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
681054 | TOF Footing | 5187 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.0885417 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0708333 | 0.0875 | 0.082021 | 0.106627 | 0.164042 | 0.213255 | 0.0546875 | 0.177083 | 0.21875 | 65 mmø-50 mmø | 0.106627 | 0.106627
632132 | TOF Footing | 1212 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.334131 | 0.0375 | 0.0708333 | 0.0656168 | 0.082021 | 0.082021 | 0.164042 | 0.0442708 | 0.09375 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
1076203 | 1D13 | 13853 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
1027658 | 1A16 | 11468 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
695101 | 1C10 | 6774 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.21875 | 10 | 0.0260417 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0875 | 0.0246063 | 0.106627 | 0.0492126 | 0.213255 | 0.0546875 | 0.0520833 | 0.21875 | 65 mmø-15 mmø | 0.106627 | 0.106627
1030255 | 2D07 | 11846 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
661868 | 1C07 | 4119 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.260417 | 10 | 0.0885417 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.0708333 | 0.104167 | 0.082021 | 0.131234 | 0.164042 | 0.262467 | 0.0651042 | 0.177083 | 0.260417 | 80 mmø-50 mmø | 0.131234 | 0.131234
1030904 | 2C12 | 11872 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
655933 | 1E12 | 3494 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
688857 | TOF Footing | 6104 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0260417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.1375 | 0.0246063 | 0.164042 | 0.0492126 | 0.328084 | 0.0859375 | 0.0520833 | 0.34375 | 100 mmø-15 mmø | 0.164042 | 0.164042
644194 | TOF Footing | 2823 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
1030798 | 2D05 | 11863 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
1047958 | 2CC3 | 12000 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
647788 | Level 1 | 3234 | Sanitary | Sanitary 1 | 10.0081 | no | no | yes | 0.177083 | 10 | 0.0885417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 1 | 0.0708333 | 0.0708333 | 0.082021 | 0.082021 | 0.164042 | 0.164042 | 0.0442708 | 0.177083 | 0.177083 | 50 mmø-50 mmø | 0.082021 | 0.0900747
691014 | TOF Footing | 6361 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
700247 | TOF Footing | 7392 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
666634 | Level 2 | 4662 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0677083 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.265087 | 0.0541667 | 0.1375 | 0.0656168 | 0.164042 | 0.131234 | 0.328084 | 0.0859375 | 0.135417 | 0.34375 | 100 mmø-40 mmø | 0.164042 | 0.164042
1050620 | 2D18 | 12672 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
644020 | TOF Footing | 2787 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.177083 | 10 | 0.0885417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0708333 | 0.0458333 | 0.082021 | 0.0524934 | 0.164042 | 0.104987 | 0.0442708 | 0.177083 | 0.114583 | 50 mmø-32 mmø | 0.0524934 | 0.0524934
682148 | TOF Footing | 5317 | Domestic Cold Water | Domestic Cold Water 1 | 10 | yes | no | no | 0.34375 | 10 | 0.171875 | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.1375 | 0.0875 | 0.164042 | 0.106627 | 0.328084 | 0.213255 | 0.0859375 | 0.34375 | 0.21875 | 100 mmø-65 mmø | 0.106627 | 0.106627
1048783 | 2D05 | 12124 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
662521 | Level 1 | 4216 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.130208 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.104167 | 0.1375 | 0.131234 | 0.164042 | 0.262467 | 0.328084 | 0.0859375 | 0.260417 | 0.34375 | 100 mmø-80 mmø | 0.164042 | 0.164042
687729 | TOF Footing | 5956 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0375 | 0.0708333 | 0.0410105 | 0.082021 | 0.082021 | 0.164042 | 0.0442708 | 0.09375 | 0.177083 | 50 mmø-25 mmø | 0.082021 | 0.082021
718492 | 1C07 | 9414 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1027341 | 1BC4 | 11372 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0054 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0710662 | 0.0656168
690842 | Level 1 | 6324 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.889794 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
679817 | TOF Footing | 5075 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0364583 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0541667 | 0.0328084 | 0.0656168 | 0.0656168 | 0.131234 | 0.0338542 | 0.0729167 | 0.135417 | 40 mmø-20 mmø | 0.0656168 | 0.0656168
1049091 | 2D05 | 12232 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
646203 | TOF Footing | 3040 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.461436 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
681271 | Level 1 | 5209 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.654113 | 0.0375 | 0.0708333 | 0.0410105 | 0.082021 | 0.082021 | 0.164042 | 0.0442708 | 0.09375 | 0.177083 | 50 mmø-25 mmø | 0.082021 | 0.082021
1008346 | 1DC1 | 10482 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
1028602 | 1AC4 | 11669 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
690252 | TOF Footing | 6271 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
679593 | Level 1 | 5062 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.371263 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
656640 | 1E08 | 3559 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.135417 | 10 | 0.0677083 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.92381 | 0.0541667 | 0.0458333 | 0.0656168 | 0.0524934 | 0.131234 | 0.104987 | 0.0338542 | 0.135417 | 0.114583 | 40 mmø-32 mmø | 0.0524934 | 0.0524934
647040 | TOF Footing | 3151 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10.0037 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.501123 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.167728 | 0.164042
645709 | TOF Footing | 2944 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 9.96894 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.461436 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.0509581 | 0.082021
680153 | TOF Footing | 5107 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1027395 | 1B15 | 11384 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1050803 | 2B10 | 12728 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1027696 | 1A01 | 11480 | Fire Protection Wet | Fire Protection | 9.99631 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.061931
