Properties of the parts of a building model (IFC2X3), part 29 of 295

# IfcFlowFitting: Standard (800)
Name | In | Level | Host | Offset (m) | Lining Width = Insulation Width | Lining Height = Insulation Height | Size | System Type | System Name | Mark | Takeoff Fixed Length | Takeoff Length Projection | Takeoff Length
M_Rectangular Elbow - Mitered:Standard:Standard:569370 | 2C12 | Level 2 | Level : Level 2 | 3.3 | 0.656168 | 1.31234 | 200x400-200x400 | Supply Air | Mechanical Supply Air 2 | 6752 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567270 | 1D25 | Level 1 | Level : Level 1 | 3.8 | 0.492126 | 1.47638 | 150x450-150x450 | Return Air | Mechanical Return Air 1 | 1497 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.47638; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566730 | 1EC1 | Level 2 | Level : Level 2 | -0.755 | 1.80446 | 0.656168 | 550x200-550x200 | Return Air | Mechanical Return Air 1 | 228 | PSet_Revit_Dimensions - Width: 1.80446; Length1: 0.984252; Height: 0.656168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567235 | 1D22 | Level 1 | Level : Level 1 | 3.8 | 0.492126 | 1.47638 | 150x450-150x450 | Return Air | Mechanical Return Air 1 | 1466 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.47638; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567598 | 1D25 | Level 1 | Level : Level 1 | 3.2905 | 1.31234 | 0.82021 | 400x250-400x250 | Supply Air | Mechanical Supply Air 1 | 2586 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.738189; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569995 | 2D06 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8376 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569024 | 2C02 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.31234 | 150x400-150x400 | Return Air | Mechanical Return Air 2 | 5741 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567111 | 1E27 | Level 1 | Level : Level 1 | 3.79 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 1 | 1215 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.31984; Height: 0.492126; Angle: 45 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-17
M_Rectangular Elbow - Mitered:Standard:Standard:566978 | 1DC1 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 1.64042 | 150x500-150x500 | Return Air | Mechanical Return Air 1 | 965 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.64042; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569991 | 2D18 | Roof - Main | Level : Roof - Main | -0.68 | 2.13255 | 0.656168 | 650x200-650x200 | Return Air | Mechanical Return Air 2 | 8371 | PSet_Revit_Dimensions - Width: 2.13255; Length1: 1.14829; Height: 0.656168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566936 | 1AC2 | Level 1 | Level : Level 1 | 3.3 | 0.492126 | 1.31234 | 150x400-150x400 | Return Air | Mechanical Return Air 1 | 884 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567105 | 1E28 | Level 1 | Level : Level 1 | 3.79 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 1 | 1206 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570474 | 2D05 | Roof - Main | Level : Roof - Main | -1.06378 | 2.78871 | 6.56168 | 850x2000-850x2000 | Return Air | Mechanical Return Air 2 | 9074 | PSet_Revit_Dimensions - Width: 2.78871; Length1: 1.47638; Height: 6.56168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:567247 | 1D25 | Level 1 | Level : Level 1 | 3.8 | 0.492126 | 1.47638 | 150x450-150x450 | Return Air | Mechanical Return Air 1 | 1480 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.47638; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569946 | 2D18 | Roof - Main | Level : Roof - Main | -0.78 | 1.47638 | 0.492126 | 450x150-450x150 | Return Air | Mechanical Return Air 2 | 8310 | PSet_Revit_Dimensions - Width: 1.47638; Length1: 0.82021; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569170 | 2C07 | Roof - Main | Level : Roof - Main | -0.73 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 6175 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567266 | 1B17 | Level 1 | Level : Level 1 | 3.3 | 2.13255 | 0.656168 | 650x200-650x200 | Return Air | Mechanical Return Air 1 | 1496 | PSet_Revit_Dimensions - Width: 2.13255; Length1: 0.523686; Height: 0.656168; Angle: 45 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:568494 | 1A03 | Level 2 | Level : Level 2 | -1.325 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 1 | 5324 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567078 | 1E06 | Level 1 | Level : Level 1 | 3.3 | 0.492126 | 1.31234 | 150x400-150x400 | Return Air | Mechanical Return Air 1 | 1180 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567423 | 1B19 | Level 1 | Level : Level 1 | 3.79958 | 0.492126 | 0.492126 | 150x150-150x150 | Supply Air | Default Supply Air (cskender) | 2076 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567093 | 1E29 | Level 1 | Level : Level 1 | 3.79 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 1 | 1195 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568553 | 1D28 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 1 | 5407 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567202 | 1D16 | Level 1 | Level : Level 1 | 3.64 | 1.14829 | 0.984252 | 350x300-350x300 | Return Air | Mechanical Return Air 1 | 1431 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.209306; Height: 0.984252; Angle: 25 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:568512 | 1D15 | Level 2 | Level : Level 2 | -0.78 | 0.492126 | 0.656168 | 150x200-150x200 | Return Air | Mechanical Return Air 1 | 5353 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.656168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567242 | 1D23 | Level 1 | Level : Level 1 | 3.8 | 0.492126 | 1.31234 | 150x400-150x400 | Return Air | Mechanical Return Air 1 | 1473 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568507 | 1D19 | Level 2 | Level : Level 2 | -0.78 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 1 | 5346 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569159 | 2A10 | Roof - Main | Level : Roof - Main | -0.73 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 6156 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570054 | 2B16 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8503 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569014 | 2C06 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.47638 | 150x450-150x450 | Return Air | Mechanical Return Air 2 | 5725 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.47638; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568248 | 1DC1 | Level 2 | Level : Level 2 | -1.0605 | 0.984252 | 0.82021 | 300x250-300x250 | Supply Air | Mechanical Supply Air 1 | 4658 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566963 | 1D13 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 1 | 932 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570176 | 2BC1 | Level 2 | Level : Level 2 | 4 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 2 | 8691 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567143 | 1E05 | Level 1 | Level : Level 1 | 3.3 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 1 | 1301 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567234 | 1D22 | Level 1 | Level : Level 1 | 3.8 | 1.47638 | 0.492126 | 450x150-450x150 | Return Air | Mechanical Return Air 1 | 1465 | PSet_Revit_Dimensions - Width: 1.47638; Length1: 0.82021; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569641 | 2B19 | Level 2 | Level : Level 2 | 3.6095 | 0.492126 | 0.82021 | 150x250-150x250 | Supply Air | Default Supply Air (cskender) | 7496 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328079; Height: 0.82021; Angle: 89.9988 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:1110993 | 1D05 | Level 1 | Level : Level 1 | 3.3 | 0.492126 | 0.656168 | 150x200-150x200 | Return Air | Mechanical Return Air 1 | 489 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.656168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566744 | 1EC3 | Level 2 | Level : Level 2 | -0.755 | 0.656168 | 0.656168 | 200x200-200x200 | Return Air | Mechanical Return Air 1 | 268 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 0.656168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567055 | 1D27 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 1 | 1091 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567100 | 1E26 | Level 1 | Level : Level 1 | 3.79 | 0.492126 | 1.31234 | 150x400-150x400 | Return Air | Mechanical Return Air 1 | 1203 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567223 | 1C14 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 1 | 1451 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569372 | 2C19 | Roof - Main | Level : Roof - Main | -1.38 | 1.31234 | 0.656168 | 400x200-400x200 | Supply Air | Mechanical Supply Air 2 | 6755 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.738189; Height: 0.656168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568467 | 1A04 | Level 2 | Level : Level 2 | -0.93 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 1 | 5269 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:569962 | 2D17 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8327 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569951 | 2D20 | Level 2 | Level : Level 2 | 4 | 0.984252 | 0.984252 | 300x300-300x300 | Return Air | Mechanical Return Air 2 | 8319 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567274 | 1D25 | Level 1 | Level : Level 1 | 3.8 | 1.47638 | 0.492126 | 450x150-450x150 | Return Air | Mechanical Return Air 1 | 1502 | PSet_Revit_Dimensions - Width: 1.47638; Length1: 0.82021; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567108 | 1E27 | Level 1 | Level : Level 1 | 3.79 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 1 | 1211 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.31984; Height: 0.492126; Angle: 45 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-17
M_Rectangular Elbow - Mitered:Standard:Standard:570468 | 2D05 | Roof - Main | Level : Roof - Main | -1.08 | 2.46063 | 2.46063 | 750x750-750x750 | Supply Air | Mechanical Supply Air 2 | 9047 | PSet_Revit_Dimensions - Width: 2.46063; Length1: 1.31234; Height: 2.46063; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:569977 | 2D11 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8354 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566921 | 1A07 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 1 | 840 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568232 | 1D16 | Level 2 | Level : Level 2 | -1.26052 | 0.82021 | 0.82021 | 250x250-250x250 | Supply Air | Mechanical Supply Air 1 | 4599 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566951 | 1C09 | Level 1 | Level : Level 1 | 3.64 | 0.656168 | 1.14829 | 200x350-200x350 | Return Air | Mechanical Return Air 1 | 914 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566972 | 1D21 | Level 2 | Level : Level 2 | -0.93 | 1.47638 | 0.656168 | 450x200-450x200 | Return Air | Mechanical Return Air 1 | 951 | PSet_Revit_Dimensions - Width: 1.47638; Length1: 0.82021; Height: 0.656168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566909 | 1A02 | Level 1 | Level : Level 1 | 3.64 | 0.984252 | 0.984252 | 300x300-300x300 | Return Air | Mechanical Return Air 1 | 811 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570473 | 2D05 | Roof - Main | Level : Roof - Main | -3.78 | 2.78871 | 6.56168 | 850x2000-850x2000 | Undefined |  | 9066 | PSet_Revit_Dimensions - Width: 2.78871; Length1: 1.47638; Height: 6.56168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:566905 | 1D36 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 1 | 800 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567083 | 1E04 | Level 1 | Level : Level 1 | 3.3 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 1 | 1183 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569890 | 2B11 | Level 2 | Level : Level 2 | 3.60952 | 0.984252 | 0.984252 | 300x300-300x300 | Supply Air | Mechanical Supply Air 2 | 8172 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568540 | 1B15 | Level 1 | Level : Level 1 | 3.3 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 1 | 5386 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570152 | 2B3 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.31234 | 150x400-150x400 | Return Air | Mechanical Return Air 2 | 8671 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568516 | 1D30 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 1 | 5357 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566904 | 1D36 | Level 1 | Level : Level 1 | 3.64 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 1 | 799 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567198 | 1D16 | Level 1 | Level : Level 1 | 3.64 | 1.14829 | 0.984252 | 350x300-350x300 | Return Air | Mechanical Return Air 1 | 1413 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:570155 | 2B3 | Roof - Main | Level : Roof - Main | -0.68 | 1.31234 | 0.492126 | 400x150-400x150 | Return Air | Mechanical Return Air 2 | 8675 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.738189; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567216 | 1C18 | Level 1 | Level : Level 1 | 3.64 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 1 | 1448 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567190 | 1D16 | Level 1 | Level : Level 1 | 3.64 | 0.984252 | 0.984252 | 300x300-300x300 | Return Air | Mechanical Return Air 1 | 1406 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567087 | 1E04 | Level 1 | Level : Level 1 | 3.3 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 1 | 1190 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568991 | 2A05 | Roof - Main | Level : Roof - Main | -0.73 | 1.31234 | 0.492126 | 400x150-400x150 | Return Air | Mechanical Return Air 2 | 5692 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.738189; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:567212 | 1C18 | Level 1 | Level : Level 1 | 3.64 | 1.31234 | 0.492126 | 400x150-400x150 | Return Air | Mechanical Return Air 1 | 1446 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.738189; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567282 | 1E24 | Level 1 | Level : Level 1 | 3.79 | 0.984252 | 2.46063 | 300x750-300x750 | Return Air | Mechanical Return Air 1 | 1515 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.285866; Height: 2.46063; Angle: 45 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:566733 | 1EC1 | Level 2 | Level : Level 2 | -0.755 | 0.984252 | 0.82021 | 300x250-300x250 | Return Air | Mechanical Return Air 1 | 235 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566880 | 1BC4 | Level 1 | Level : Level 1 | 3.3 | 0.656168 | 0.328084 | 200x100-200x100 | Return Air | Mechanical Return Air 1 | 767 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 0.328084; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566935 | 1AC2 | Level 2 | Level : Level 2 | -1.27 | 1.31234 | 0.492126 | 400x150-400x150 | Return Air | Mechanical Return Air 1 | 883 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.738189; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569979 | 2D11 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8357 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566713 | 1CC1 | Level 2 | Level : Level 2 | -0.93 | 3.77297 | 1.31234 | 1150x400-1150x400 | Return Air | Mechanical Return Air 1 | 43 | PSet_Revit_Dimensions - Width: 3.77297; Length1: 1.9685; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:570501 | 1D12 | Level 2 | Level : Level 2 | -0.78 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 1 | 9165 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570787 | 2D05 | Roof - Main | Level : Roof - Main | -1.06378 | 4.26509 | 3.28084 | 1300x1000-1300x1000 | Return Air | Mechanical Return Air 2 | 715 | PSet_Revit_Dimensions - Width: 4.26509; Length1: 2.21457; Height: 3.28084; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:567124 | 1E24 | Level 1 | Level : Level 1 | 3.79 | 0.984252 | 0.984252 | 300x300-300x300 | Return Air | Mechanical Return Air 1 | 1225 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570199 | 2D05 | Roof - Main | Level : Roof - Main | -1.06378 | 4.26509 | 3.28084 | 1300x1000-1300x1000 | Return Air | Mechanical Return Air 2 | 8744 | PSet_Revit_Dimensions - Width: 4.26509; Length1: 2.21457; Height: 3.28084; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:570024 | 2DC2 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.47638 | 150x450-150x450 | Return Air | Mechanical Return Air 2 | 8407 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.47638; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569149 | 2C01 | Level 2 | Level : Level 2 | 3.95 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 6144 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569019 | 2C04 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.47638 | 150x450-150x450 | Return Air | Mechanical Return Air 2 | 5732 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.47638; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567200 | 1D16 | Level 1 | Level : Level 1 | 3.64 | 1.14829 | 0.984252 | 350x300-350x300 | Return Air | Mechanical Return Air 1 | 1418 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.209306; Height: 0.984252; Angle: 25 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:570444 | 2D05 | Level 2 | Level : Level 2 | 0.9 | 2.95276 | 2.95276 | 900x900-900x900 | Supply Air | Mechanical Supply Air 1 | 8993 | PSet_Revit_Dimensions - Width: 2.95276; Length1: 1.5584; Height: 2.95276; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570469 | 2D05 | Roof - Main | Level : Roof - Main | -3.78 | 2.46063 | 2.46063 | 750x750-750x750 | Supply Air | Mechanical Supply Air 2 | 9058 | PSet_Revit_Dimensions - Width: 2.46063; Length1: 1.31234; Height: 2.46063; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:569944 | 2D21 | Level 2 | Level : Level 2 | 3.9 | 0.492126 | 1.47638 | 150x450-150x450 | Return Air | Mechanical Return Air 2 | 8307 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.47638; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570231 | 2D05 | Roof - Main | Level : Roof - Main | -1.08 | 2.46063 | 2.46063 | 750x750-750x750 | Supply Air | Mechanical Supply Air 2 | 8826 | PSet_Revit_Dimensions - Width: 2.46063; Length1: 0.347422; Height: 2.46063; Angle: 24.3464 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-17
M_Rectangular Elbow - Mitered:Standard:Standard:567391 | 1EC2 | Level 1 | Level : Level 1 | 3.7995 | 0.984252 | 0.984252 | 300x300-300x300 | Supply Air | Default Supply Air (cskender) | 1901 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574128; Height: 0.984252; Angle: 89.9978 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570464 | 2D05 | Roof - Main | Level : Roof - Main | -3.78 | 2.46063 | 2.46063 | 750x750-750x750 | Supply Air | Mechanical Supply Air 2 | 9043 | PSet_Revit_Dimensions - Width: 2.46063; Length1: 1.31234; Height: 2.46063; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566968 | 1D21 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 1.31234 | 150x400-150x400 | Return Air | Mechanical Return Air 1 | 942 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567132 | 1EC1 | Level 1 | Level : Level 1 | 3.3 | 0.82021 | 1.14829 | 250x350-250x350 | Return Air | Mechanical Return Air 1 | 1255 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569676 | 2BC2 | Roof - Main | Level : Roof - Main | -1.0705 | 0.984252 | 0.82021 | 300x250-300x250 | Supply Air | Default Supply Air (cskender) | 7576 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567170 | 1D06 | Level 1 | Level : Level 1 | 3.3 | 1.14829 | 0.656168 | 350x200-350x200 | Return Air | Mechanical Return Air 1 | 1369 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.656168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566931 | 1D05 | Level 2 | Level : Level 2 | -1.27 | 0.656168 | 0.492126 | 200x150-200x150 | Return Air | Mechanical Return Air 1 | 871 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567025 | 1D34 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 1 | 1055 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570225 | 2D05 | Roof - Main | Level : Roof - Main | -1.08 | 2.46063 | 2.46063 | 750x750-750x750 | Supply Air | Mechanical Supply Air 2 | 8805 | PSet_Revit_Dimensions - Width: 2.46063; Length1: 0.423218; Height: 2.46063; Angle: 31 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:570181 | 2D03 | Level 2 | Level : Level 2 | 4 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 2 | 8698 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567157 | 1DC3 | Level 1 | Level : Level 1 | 3.3 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 1 | 1354 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568557 | 1D24 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 1 | 5413 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566973 | 1D16 | Level 1 | Level : Level 1 | 3.64 | 0.984252 | 0.984252 | 300x300-300x300 | Return Air | Mechanical Return Air 1 | 952 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568362 | 1C05 | Level 2 | Level : Level 2 | -1.2105 | 0.492126 | 0.82021 | 150x250-150x250 | Supply Air | Mechanical Supply Air 1 | 5046 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.15026; Height: 0.82021; Angle: 31 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:567210 | 1C18 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 1.31234 | 150x400-150x400 | Return Air | Mechanical Return Air 1 | 1443 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570437 | 2D05 | Roof - Main | Level : Roof - Main | -1.48 | 0.984252 | 2.29659 | 300x700-300x700 | Supply Air | Mechanical Supply Air 1 | 8963 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 2.29659; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570502 | 1D10 | Level 1 | Level : Level 1 | 3.79 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 1 | 9166 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570079 | 2B24 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.984252 | 350x300-350x300 | Return Air | Mechanical Return Air 2 | 8552 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568975 | Level 2 | Roof - Main | Level : Roof - Main | -0.73 | 3.93701 | 1.64042 | 1200x500-1200x500 | Return Air | Mechanical Return Air 2 | 5598 | PSet_Revit_Dimensions - Width: 3.93701; Length1: 2.05052; Height: 1.64042; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:568544 | 1D40 | Level 1 | Level : Level 1 | 3.715 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 1 | 5394 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568585 | 1E25 | Level 1 | Level : Level 1 | 3.79 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 1 | 5445 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570221 | 2D05 | Roof - Main | Level : Roof - Main | -1.48 | 2.29659 | 0.984252 | 700x300-700x300 | Supply Air | Mechanical Supply Air 1 | 8797 | PSet_Revit_Dimensions - Width: 2.29659; Length1: 0.400471; Height: 0.984252; Angle: 31 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-17
M_Rectangular Elbow - Mitered:Standard:Standard:569168 | 2C22 | Level 2 | Level : Level 2 | 3.95 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 6172 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570037 | 2BC1 | Roof - Main | Level : Roof - Main | -0.68 | 2.62467 | 1.31234 | 800x400-800x400 | Return Air | Mechanical Return Air 2 | 8471 | PSet_Revit_Dimensions - Width: 2.62467; Length1: 0.625608; Height: 1.31234; Angle: 45 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:567711 | 1AC1 | Level 1 | Level : Level 1 | 3.42 | 1.14829 | 0.82021 | 350x250-350x250 | Supply Air | Default Supply Air (cskender) | 2929 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569153 | 2A10 | Level 2 | Level : Level 2 | 3.95 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 6147 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567029 | 1D32 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 1 | 1062 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567566 | 1BC1 | Level 1 | Level : Level 1 | 3.79952 | 0.82021 | 0.82021 | 250x250-250x250 | Supply Air | Mechanical Supply Air 1 | 2394 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569123 | 2A02 | Level 2 | Level : Level 2 | 3.95 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 6095 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568474 | 1C10 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 1 | 5288 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569714 | 2DC2 | Roof - Main | Level : Roof - Main | -1.0705 | 0.656168 | 0.82021 | 200x250-200x250 | Supply Air | Mechanical Supply Air 2 | 7698 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.217918; Height: 0.82021; Angle: 45 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-17
M_Rectangular Elbow - Mitered:Standard:Standard:568360 | 1C04 | Level 2 | Level : Level 2 | -1.2105 | 0.492126 | 0.82021 | 150x250-150x250 | Supply Air | Mechanical Supply Air 1 | 5045 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.15026; Height: 0.82021; Angle: 31 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:569005 | 2C14 | Roof - Main | Level : Roof - Main | -0.68 | 1.47638 | 0.492126 | 450x150-450x150 | Return Air | Mechanical Return Air 2 | 5719 | PSet_Revit_Dimensions - Width: 1.47638; Length1: 0.82021; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569003 | 2C14 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.47638 | 150x450-150x450 | Return Air | Mechanical Return Air 2 | 5716 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.47638; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569044 | 2A06 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.31234 | 150x400-150x400 | Return Air | Mechanical Return Air 2 | 5769 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:1118591 | 1D02 | Level 1 | Level : Level 1 | 3.3 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 1 | 877 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567063 | 1D36 | Level 1 | Level : Level 1 | 3.64 | 0.984252 | 3.60892 | 300x1100-300x1100 | Return Air | Mechanical Return Air 1 | 1106 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.285866; Height: 3.60892; Angle: 45 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:567815 | 1D30 | Level 1 | Level : Level 1 | 3.319 | 0.656168 | 0.82021 | 200x250-200x250 | Supply Air | Mechanical Supply Air 1 | 3171 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568144 | 1C15 | Level 2 | Level : Level 2 | -1.2605 | 0.492126 | 0.82021 | 150x250-150x250 | Supply Air | Mechanical Supply Air 1 | 4325 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568549 | 1D33 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 1 | 5403 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569009 | 2C09 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.47638 | 150x450-150x450 | Return Air | Mechanical Return Air 2 | 5721 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.47638; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567392 | 1EC2 | Level 1 | Level : Level 1 | 3.5 | 0.984252 | 0.984252 | 300x300-300x300 | Supply Air | Mechanical Supply Air 1 | 1904 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566913 | 1A06 | Level 2 | Level : Level 2 | -0.93 | 1.9685 | 0.656168 | 600x200-600x200 | Return Air | Mechanical Return Air 1 | 822 | PSet_Revit_Dimensions - Width: 1.9685; Length1: 1.06627; Height: 0.656168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566814 | 1A16 | Level 2 | Level : Level 2 | -1.325 | 0.656168 | 0.656168 | 200x200-200x200 | Return Air | Mechanical Return Air 1 | 562 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 0.656168; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568311 | 1DC2 | Level 2 | Level : Level 2 | -0.860492 | 0.82021 | 0.492126 | 250x150-250x150 | Supply Air | Mechanical Supply Air 1 | 4904 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569295 | 2C03 | Roof - Main | Level : Roof - Main | -1.0705 | 0.492126 | 0.82021 | 150x250-150x250 | Supply Air | Mechanical Supply Air 2 | 6522 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568579 | 1E18 | Level 1 | Level : Level 1 | 3.815 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 1 | 5438 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568353 | 1D02 | Level 2 | Level : Level 2 | -0.840924 | 1.31234 | 0.82021 | 400x250-400x250 | Supply Air | Default Supply Air (cskender) | 5012 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.353815; Height: 0.82021; Angle: 45 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-17
M_Rectangular Elbow - Mitered:Standard:Standard:570130 | 2B15 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8628 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566849 | 1B03 | Level 1 | Level : Level 1 | 3.3 | 0.984252 | 0.82021 | 300x250-300x250 | Return Air | Mechanical Return Air 1 | 669 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:1118929 | 1D38 | Level 1 | Level : Level 1 | 3.4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 1 | 895 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569029 | 2A09 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.31234 | 150x400-150x400 | Return Air | Mechanical Return Air 2 | 5748 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567722 | 1BC4 | Level 1 | Level : Level 1 | 3.6995 | 1.31234 | 0.984252 | 400x300-400x300 | Supply Air | Default Supply Air (cskender) | 2950 | PSet_Revit_Dimensions - Width: 1.31234; Length1: 0.738189; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568521 | 1DC1 | Level 1 | Level : Level 1 | 3.64 | 0.984252 | 0.984252 | 300x300-300x300 | Return Air | Mechanical Return Air 1 | 5368 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569039 | 2A07 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.31234 | 150x400-150x400 | Return Air | Mechanical Return Air 2 | 5762 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570463 | 2D05 | Roof - Main | Level : Roof - Main | -1.08 | 2.46063 | 2.46063 | 750x750-750x750 | Supply Air | Mechanical Supply Air 2 | 9032 | PSet_Revit_Dimensions - Width: 2.46063; Length1: 1.31234; Height: 2.46063; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570191 | 2D04-A | Level 2 | Level : Level 2 | 4 | 0.984252 | 0.984252 | 300x300-300x300 | Return Air | Mechanical Return Air 2 | 8710 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567131 | 1EC1 | Level 1 | Level : Level 1 | 3.3 | 1.14829 | 0.82021 | 350x250-350x250 | Return Air | Mechanical Return Air 1 | 1254 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:569712 | 2DC2 | Roof - Main | Level : Roof - Main | -1.0705 | 0.656168 | 0.82021 | 200x250-200x250 | Supply Air | Mechanical Supply Air 2 | 7697 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.217918; Height: 0.82021; Angle: 45 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-17
M_Rectangular Elbow - Mitered:Standard:Standard:569051 | 2AC5 | Level 2 | Level : Level 2 | 4 | 0.492126 | 0.82021 | 150x250-150x250 | Return Air | Mechanical Return Air 2 | 5799 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570602 | 1BC1 | Level 2 | Level : Level 2 | -1.116 | 0.492126 | 0.82021 | 150x250-150x250 | Supply Air | Default Supply Air (cskender) | 211 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:1121358 | 1B16 | Level 1 | Level : Level 1 | 3.2 | 0.984252 | 0.984252 | 300x300-300x300 | Supply Air | Mechanical Supply Air 1 | 1173 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570139 | 2B14 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8634 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570009 | 2D10 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8392 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566842 | 1DC7 | Level 1 | Level : Level 1 | 3.715 | 3.28084 | 0.984252 | 1000x300-1000x300 | Return Air | Mechanical Return Air 1 | 630 | PSet_Revit_Dimensions - Width: 3.28084; Length1: 1.72244; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:570134 | 2B10 | Level 2 | Level : Level 2 | 4 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 2 | 8630 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568312 | 1DC2 | Level 2 | Level : Level 2 | -1.27 | 0.82021 | 0.492126 | 250x150-250x150 | Supply Air | Mechanical Supply Air 1 | 4907 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:567118 | 1E24 | Level 1 | Level : Level 1 | 3.79 | 0.984252 | 0.984252 | 300x300-300x300 | Return Air | Mechanical Return Air 1 | 1220 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.574147; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570029 | 2DC2 | Roof - Main | Level : Roof - Main | -0.68 | 3.28084 | 1.31234 | 1000x400-1000x400 | Return Air | Mechanical Return Air 2 | 8414 | PSet_Revit_Dimensions - Width: 3.28084; Length1: 1.72244; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:570050 | 2BC3 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8501 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570172 | 2D01 | Roof - Main | Level : Roof - Main | -0.68 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 2 | 8689 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.492126; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:1138352 | 1C19 | Level 1 | Level : Level 1 | 3.64 | 0.492126 | 1.14829 | 150x350-150x350 | Return Air | Mechanical Return Air 1 | 1403 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 1.14829; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570201 | 2DC2 | Roof - Main | Level : Roof - Main | -0.68 | 3.28084 | 1.31234 | 1000x400-1000x400 | Return Air | Mechanical Return Air 2 | 8753 | PSet_Revit_Dimensions - Width: 3.28084; Length1: 1.72244; Height: 1.31234; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:567138 | 1E11 | Level 1 | Level : Level 1 | 3.3 | 1.14829 | 0.82021 | 350x250-350x250 | Return Air | Mechanical Return Air 1 | 1265 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.82021; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:568109 | 1C12 | Level 2 | Level : Level 2 | -1.2605 | 0.492126 | 0.984252 | 150x300-150x300 | Supply Air | Mechanical Supply Air 1 | 4212 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.984252; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: SR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:570207 | 2D05 | Roof - Main | Level : Roof - Main | -0.78 | 2.29659 | 1.64042 | 700x500-700x500 | Return Air | Mechanical Return Air 2 | 8771 | PSet_Revit_Dimensions - Width: 2.29659; Length1: 1.23192; Height: 1.64042; Angle: 90.0801 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021
M_Rectangular Elbow - Mitered:Standard:Standard:568556 | 1D24 | Level 2 | Level : Level 2 | -0.93 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 1 | 5412 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.492126; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
M_Rectangular Elbow - Mitered:Standard:Standard:566884 | 1BC4 | Level 1 | Level : Level 1 | 3.3 | 0.656168 | 0.328084 | 200x100-200x100 | Return Air | Mechanical Return Air 1 | 769 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.410105; Height: 0.328084; Angle: 90 deg; PSet_Revit_Type_Dimensions - Shoulder: 0.082021; PSet_Revit_Mechanical - ASHRAE Table: CR3-1
