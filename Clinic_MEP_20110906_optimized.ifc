Properties of the parts of a building model (IFC2X3), part 13 of 295

# IfcFlowFitting: 45 Degree (707)
Name | In | Length 2 | Length 1 | Mark | System Type | System Name | ASHRAE Table | Level | Host | Offset (m) | Size | OffsetHeight | OffsetWidth | Num8 | Num7 | Num6 | Num5 | Num4 | Num3 | Num2 | Num1 | PSet_Revit_Other, Delta 2 | PSet_Revit_Other, Delta 1 | WidthOffset | WidthDelta | Width2 = Lining Width 2 = Insulation Width 2 | Width1 = Lining Width 1 = Insulation Width 1 | MaxDelta = Length 01 = Computed Length | Lining Height 2 = Insulation Height 2 = Height2 | Lining Height 1 = Insulation Height 1 = Height1 | HeightOffset | HeightDelta | Half Width 2 | Half Width 1 | Half Height 2 | Half Height 1
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570376 | 2D17 | 0.082021 | 0.082021 | 8922 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570267 | 2A11 | 0.164042 | 0.164042 | 8863 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:566716 | 1CC1 | 0.396032 | 0.198016 | 66 | Return Air | Mechanical Return Air 1 |  | Level 2 | Level : Level 2 | -0.93 | 1100x350-1000x350 | 0.574147 | 1.80446 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 3.28084 | 3.60892 | 0.396032 | 1.14829 | 1.14829 | 10 | 0 | 1.64042 | 1.80446 | 0.574147 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:568402 | 1D36 | 0.396032 | 0.198016 | 5158 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -0.770475 | 250x200-150x250 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.246063 | 0.410105 | 0.410105 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:568486 | 1A16 | 0.198016 | 0.198016 | 5303 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -1.325 | 250x200-250x150 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.82021 | 0.82021 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.410105 | 0.410105 | 0.246063 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:569963 | 2D17 | 0.198016 | 0.594049 | 8328 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569867 | 2B8 | 0.396032 | 0.198016 | 8098 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07048 | 250x200-150x250 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.246063 | 0.410105 | 0.410105 | 0.328084
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:569202 | 2C14 | 0 | 0 | 6239 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-300ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 0; Num 7: 0; Num 6: 0; Num 10: 0; Num 1: 0; Length 8: 0; Length 7: 0; Length 6: 0; Length 5: 0; Length 4: 0; Half H0: 0.492126; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0; Delta 1: 0; W0: 0.984252; Radius: 0.492126; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.492126; Lining H0: 0.984252; Length01: 0.246063; Insulation W0: 0.984252; Insulation Radius: 0.492126; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.984252
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568421 | 1B04 | 0.082021 | 0.082021 | 5202 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 350ø-300x300 | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.574147; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.574147; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.574147; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 1.14829
M_Rectangular Transition - Angle:45 Degree:45 Degree:569169 | 2C22 | 0.198016 | 0.594049 | 6173 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.66893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:566910 | 1A02 | 1.1881 | 0.396032 | 812 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.64 | 600x200-300x300 | 0.492126 | 0.492126 | 2 | 4 | 2 | 2 | 6 | 36 | 6 | 6 | 0 | 0 | 10 | 0.984252 | 1.9685 | 0.984252 | 1.1881 | 0.656168 | 0.984252 | 10 | 0.328084 | 0.984252 | 0.492126 | 0.328084 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569716 | 2DC2 | 0.198016 | 0.198016 | 7705 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.0705 | 200x250-150x250 | 0.410105 | 0.328084 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.492126 | 0.656168 | 0.198016 | 0.82021 | 0.82021 | 10 | 0 | 0.246063 | 0.328084 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:568550 | 1D33 | 0.198016 | 0.594049 | 5404 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.35893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568446 | 1D07 | 0 | 0 | 5237 | Supply Air | Mechanical Supply Air 1 | SD4-2 | Level 1 | Level : Level 1 | 3.70948 | 200x250-200ø | 0.410105 | 0.328084 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 0; Length 8: 0; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.410105; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.328084; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0; W0: 0.656168; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.656168; Lining Radius: 0.328084; Lining H0: 0.82021; Length01: 0.198016; Insulation W0: 0.656168; Insulation Radius: 0.328084; Insulation H0: 0.82021; H0: 0.82021; OffsetWidthTemp: -0.0277778; OffsetHeightTemp: 0.0347222; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:567001 | 1B03 | 0.198016 | 0.198016 | 1010 | Return Air | Mechanical Return Air 1 |  | Level 1 | Level : Level 1 | 3.3 | 300x300-300x250 | 0.410105 | 0.492126 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.984252 | 0.984252 | 0.198016 | 0.984252 | 0.82021 | 10 | 0.164042 | 0.492126 | 0.492126 | 0.492126 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:570041 | 2B10 | 1.1881 | 0.198016 | 8487 | Return Air | Mechanical Return Air 2 |  | Roof - Main | Level : Roof - Main | -0.68 | 700x350-400x350 | 0.574147 | 1.14829 | 1 | 1 | 1 | 1 | 6 | 36 | 6 | 6 | 0 | 0 | 10 | 0.984252 | 1.31234 | 2.29659 | 1.1881 | 1.14829 | 1.14829 | 10 | 0 | 0.656168 | 1.14829 | 0.574147 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:570539 | Level 1 | 2.17818 | 0.594049 | 9242 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 2 | Level : Level 2 | -1.25094 | 800x300-250x150 | 0.246063 | 0.410105 | 3 | 9 | 3 | 3 | 11 | 121 | 11 | 11 | 0 | 0 | 10 | 1.80446 | 2.62467 | 0.82021 | 2.17818 | 0.984252 | 0.492126 | 10 | 0.492126 | 1.31234 | 0.410105 | 0.492126 | 0.246063
M_Rectangular Transition - Angle:45 Degree:45 Degree:566734 | 1EC1 | 0.990081 | 0.198016 | 236 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.755 | 550x250-300x250 | 0.410105 | 0.492126 | 1 | 1 | 1 | 1 | 5 | 25 | 5 | 5 | 0 | 0 | 10 | 0.82021 | 1.80446 | 0.984252 | 0.990081 | 0.82021 | 0.82021 | 10 | 0 | 0.902231 | 0.492126 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:569030 | 2A09 | 0.396032 | 0.594049 | 5749 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-400x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 1.31234 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.656168 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:566969 | 1D21 | 0.396032 | 0.594049 | 943 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.35893 | 300x300-400x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 1.31234 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.656168 | 0.492126 | 0.246063 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567630 | 1DC7 | 0.246063 | 0.246063 | 2643 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569758 | 2D21 | 0.594049 | 0.198016 | 7814 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07048 | 350x300-200x300 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.656168 | 1.14829 | 0.594049 | 0.984252 | 0.984252 | 10 | 0 | 0.328084 | 0.574147 | 0.492126 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568513 | 1D15 | 0.396032 | 0.594049 | 5354 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.88 | 300x300-200x150 | 0.246063 | 0.328084 | 3 | 9 | 3 | 3 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.984252 | 0.656168 | 0.594049 | 0.984252 | 0.492126 | 10 | 0.492126 | 0.492126 | 0.328084 | 0.492126 | 0.246063
M_Rectangular Transition - Angle:45 Degree:45 Degree:569423 | 2A03 | 0.297024 | 0.198016 | 6852 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07045 | 275x250-200x300 | 0.409941 | 0.451115 | 1 | 1 | 0.998 | 1.002 | 1.5 | 2.25 | 1.5 | 1.5 | 0.000164042 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.297024 | 0.984252 | 0.82021 | 9.99984 | 0.164042 | 0.328084 | 0.451115 | 0.492126 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570396 | 2D07 | 0.082021 | 0.082021 | 8933 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular Transition - Angle:45 Degree:45 Degree:568548 | Level 1 | 0.198016 | 1.1881 | 5402 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.64 | 350x450-350x150 | 0.738189 | 0.574147 | 6 | 36 | 6 | 6 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 1.1881 | 0.492126 | 1.47638 | 10 | 0.984252 | 0.574147 | 0.574147 | 0.246063 | 0.738189
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567569 | 1B01 | 0.246063 | 0.246063 | 2397 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:566789 | 1D05 | 0.198016 | 0.198016 | 446 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -1.27 | 350x200-300x200 | 0.328084 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.984252 | 1.14829 | 0.198016 | 0.656168 | 0.656168 | 10 | 0 | 0.492126 | 0.574147 | 0.328084 | 0.328084
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570424 | 2A11 | 0.164042 | 0.164042 | 8951 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:567275 | 1A06 | 0.198016 | 1.1881 | 1505 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.12787 | 300x600-300x300 | 0.492126 | 0.492126 | 6 | 36 | 6 | 6 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.984252 | 0.984252 | 1.1881 | 1.9685 | 0.984252 | 10 | 0.984252 | 0.492126 | 0.492126 | 0.984252 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569367 | 2C19 | 0.198016 | 0.396032 | 6748 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.38 | 350x300-400x200 | 0.492126 | 0.574147 | 2 | 4 | 2 | 2 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.31234 | 1.14829 | 0.396032 | 0.656168 | 0.984252 | 10 | 0.328084 | 0.656168 | 0.574147 | 0.328084 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570536 | 1AC1 | 2.17818 | 0.594049 | 9239 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 2 | Level : Level 2 | -1.116 | 800x300-250x150 | 0.246063 | 0.410105 | 3 | 9 | 3 | 3 | 11 | 121 | 11 | 11 | 0 | 0 | 10 | 1.80446 | 2.62467 | 0.82021 | 2.17818 | 0.984252 | 0.492126 | 10 | 0.492126 | 1.31234 | 0.410105 | 0.492126 | 0.246063
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:569214 | 2C13 | 0.246063 | 0.246063 | 6280 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569646 | 2B15 | 0.198016 | 0.198016 | 7508 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07048 | 350x300-300x250 | 0.491962 | 0.574147 | 1 | 1 | 0.998 | 1.002 | 1 | 1 | 1 | 1 | 0.000164042 | 0 | 10 | 0.164042 | 0.984252 | 1.14829 | 0.198016 | 0.82021 | 0.984252 | 9.99984 | 0.164042 | 0.492126 | 0.574147 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567028 | Level 1 | 0.198016 | 1.1881 | 1061 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.64 | 250x450-250x150 | 0.738189 | 0.410105 | 6 | 36 | 6 | 6 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.82021 | 0.82021 | 1.1881 | 0.492126 | 1.47638 | 10 | 0.984252 | 0.410105 | 0.410105 | 0.246063 | 0.738189
M_Rectangular Transition - Angle:45 Degree:45 Degree:566920 | 1A07 | 0.198016 | 0.792065 | 839 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.93 | 350x350-350x150 | 0.574147 | 0.574147 | 4 | 16 | 4 | 4 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.792065 | 0.492126 | 1.14829 | 10 | 0.656168 | 0.574147 | 0.574147 | 0.246063 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:569996 | 2D06 | 0.594049 | 0.198016 | 8377 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-150x350 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.574147 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568520 | 1DC1 | 0.198016 | 0.198016 | 5367 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.93 | 650x300-650x250 | 0.492126 | 1.06627 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 2.13255 | 2.13255 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 1.06627 | 1.06627 | 0.410105 | 0.492126
M_Round Transition - Angle:45 Degree:45 Degree:567585 | 1D25 | 0.082021 | 0.082021 | 2517 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 1 | Level : Level 1 | 3.28098 | 450ø-400ø | 0.738189 | 0.738189 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0615157; OffsetHeightTemp: 0.0615157; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.656168; R0: 0.738189; Lining Radius 1: 0.656168; Lining Radius 0: 0.738189; Insulation Radius 1: 0.656168; Insulation Radius 0: 0.738189; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular Transition - Angle:45 Degree:45 Degree:566871 | 1B15 | 0.198016 | 0.594049 | 745 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.3 | 250x300-250x150 | 0.492126 | 0.410105 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.82021 | 0.82021 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 0.410105 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568212 | 1D22 | 0.396032 | 0.198016 | 4532 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.36048 | 350x300-250x300 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.82021 | 1.14829 | 0.396032 | 0.984252 | 0.984252 | 10 | 0 | 0.410105 | 0.574147 | 0.492126 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569015 | 2C06 | 0.594049 | 0.594049 | 5726 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-450x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 1.47638 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.738189 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569277 | 2C09 | 0.297024 | 0.396032 | 6447 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.1705 | 200x350-275x250 | 0.410105 | 0.451115 | 2 | 4 | 2 | 2 | 1.5 | 2.25 | 1.5 | 1.5 | 0 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.396032 | 1.14829 | 0.82021 | 10 | 0.328084 | 0.328084 | 0.451115 | 0.574147 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:567079 | 1E06 | 0.594049 | 0.396032 | 1181 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.01893 | 300x300-150x400 | 0.492126 | 0.492126 | 2 | 4 | 2 | 2 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.31234 | 0.984252 | 10 | 0.328084 | 0.246063 | 0.492126 | 0.656168 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569440 | 2A08 | 0.495041 | 0.396032 | 6879 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.12995 | 275x250-150x350 | 0.409941 | 0.451115 | 2 | 4 | 1.998 | 2.002 | 2.5 | 6.25 | 2.5 | 2.5 | 0.000164042 | 0 | 10 | 0.410105 | 0.492126 | 0.902231 | 0.495041 | 1.14829 | 0.82021 | 9.99984 | 0.328084 | 0.246063 | 0.451115 | 0.574147 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568177 | 1C01 | 0.246063 | 0.246063 | 4416 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567465 | 1B04 | 0.082021 | 0.082021 | 2187 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 350ø-300x300 | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.574147; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.574147; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.574147; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 1.14829
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570275 | 2CC2 | 0.246063 | 0.246063 | 8867 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567987 | 1A16 | 0.198016 | 0.198016 | 3839 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -0.8605 | 300x300-250x250 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.410105 | 0.492126 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569148 | Level 2 | 0.198016 | 0.990081 | 6143 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.73 | 350x400-350x150 | 0.656168 | 0.574147 | 5 | 25 | 5 | 5 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.990081 | 0.492126 | 1.31234 | 10 | 0.82021 | 0.574147 | 0.574147 | 0.246063 | 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:569437 | 2A07 | 0.495041 | 0.396032 | 6874 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.09995 | 275x250-150x350 | 0.409941 | 0.451115 | 2 | 4 | 1.998 | 2.002 | 2.5 | 6.25 | 2.5 | 2.5 | 0.000164042 | 0 | 10 | 0.410105 | 0.492126 | 0.902231 | 0.495041 | 1.14829 | 0.82021 | 9.99984 | 0.328084 | 0.246063 | 0.451115 | 0.574147 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:570527 | 1AC1 | 2.17818 | 0.594049 | 9195 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 2 | Level : Level 2 | -1.116 | 800x300-250x150 | 0.246063 | 0.410105 | 3 | 9 | 3 | 3 | 11 | 121 | 11 | 11 | 0 | 0 | 10 | 1.80446 | 2.62467 | 0.82021 | 2.17818 | 0.984252 | 0.492126 | 10 | 0.492126 | 1.31234 | 0.410105 | 0.492126 | 0.246063
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567780 | 1D36 | 0 | 0 | 3124 | Supply Air | Mechanical Supply Air 1 | SD4-2 | Level 1 | Level : Level 1 | 3.3096 | 150x250-150ø | 0.410105 | 0.246063 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 0; Length 8: 0; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.410105; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.246063; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0; W0: 0.492126; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.492126; Lining Radius: 0.246063; Lining H0: 0.82021; Length01: 0.396032; Insulation W0: 0.492126; Insulation Radius: 0.246063; Insulation H0: 0.82021; H0: 0.82021; OffsetWidthTemp: -0.0208333; OffsetHeightTemp: 0.0347222; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569693 | 2D01 | 0.594049 | 0.198016 | 7621 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07048 | 350x300-200x250 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.656168 | 1.14829 | 0.594049 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.328084 | 0.574147 | 0.410105 | 0.492126
M_Round Transition - Angle:45 Degree:45 Degree:567977 | 1AC5 | 0.164042 | 0.164042 | 3777 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 2 | Level : Level 2 | -0.87 | 350ø-250ø | 0.574147 | 0.574147 | PSet_Revit_Other - Num 1: 1.9685; Num 5: 4.75239; Num 4: 1; Num 3: 3.93701; Num 2: 1.9685; Length 3: 1.77636e-15; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0478456; OffsetHeightTemp: 0.0478456; WidthOffsetfromBase: 10; Offest Delta: 4.9738e-14; DiameterDelta: 0.164042; R1: 0.410105; R0: 0.574147; Lining Radius 1: 0.410105; Lining Radius 0: 0.574147; Insulation Radius 1: 0.410105; Insulation Radius 0: 0.574147; HeightOffsetfromBase: 10; ComputedLength: 0.396032
M_Rectangular Transition - Angle:45 Degree:45 Degree:569165 | 2C03 | 0.198016 | 0.396032 | 6168 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.73 | 350x250-350x150 | 0.410105 | 0.574147 | 2 | 4 | 2 | 2 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.396032 | 0.492126 | 0.82021 | 10 | 0.328084 | 0.574147 | 0.574147 | 0.246063 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568664 | 1E14 | 0.246063 | 0.246063 | 5502 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568067 | 1C08 | 0.198016 | 0.198016 | 4076 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.21049 | 300x200-250x200 | 0.328084 | 0.492126 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.198016 | 0.656168 | 0.656168 | 10 | 0 | 0.410105 | 0.492126 | 0.328084 | 0.328084
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570271 | 2A08 | 0 | 0 | 8865 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-300ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 0; Num 7: 0; Num 6: 0; Num 10: 0; Num 1: 0; Length 8: 0; Length 7: 0; Length 6: 0; Length 5: 0; Length 4: 0; Half H0: 0.492126; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0; Delta 1: 0; W0: 0.984252; Radius: 0.492126; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.492126; Lining H0: 0.984252; Length01: 0.246063; Insulation W0: 0.984252; Insulation Radius: 0.492126; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.984252
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568676 | 1EC4 | 0.246063 | 0.246063 | 5509 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568667 | 1E14 | 0.246063 | 0.246063 | 5504 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570277 | 2A09 | 0 | 0 | 8868 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-300ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 0; Num 7: 0; Num 6: 0; Num 10: 0; Num 1: 0; Length 8: 0; Length 7: 0; Length 6: 0; Length 5: 0; Length 4: 0; Half H0: 0.492126; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0; Delta 1: 0; W0: 0.984252; Radius: 0.492126; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.492126; Lining H0: 0.984252; Length01: 0.246063; Insulation W0: 0.984252; Insulation Radius: 0.492126; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.984252
M_Rectangular Transition - Angle:45 Degree:45 Degree:569293 | 2C03 | 0.396032 | 0.198016 | 6515 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07048 | 250x200-150x250 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.246063 | 0.410105 | 0.410105 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:569952 | 2D20 | 0.990081 | 0.396032 | 8320 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 4 | 550x200-300x300 | 0.492126 | 0.492126 | 2 | 4 | 2 | 2 | 5 | 25 | 5 | 5 | 0 | 0 | 10 | 0.82021 | 1.80446 | 0.984252 | 0.990081 | 0.656168 | 0.984252 | 10 | 0.328084 | 0.902231 | 0.492126 | 0.328084 | 0.492126
M_Round Transition - Angle:45 Degree:45 Degree:568268 | 1DC3 | 0.082021 | 0.082021 | 4767 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 2 | Level : Level 2 | -0.87 | 450ø-400ø | 0.738189 | 0.738189 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0615157; OffsetHeightTemp: 0.0615157; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.656168; R0: 0.738189; Lining Radius 1: 0.656168; Lining Radius 0: 0.738189; Insulation Radius 1: 0.656168; Insulation Radius 0: 0.738189; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular Transition - Angle:45 Degree:45 Degree:567421 | 1B19 | 0.396032 | 0.198016 | 2073 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.79953 | 250x200-150x150 | 0.328248 | 0.410105 | 1 | 1 | 0.998 | 1.002 | 2 | 4 | 2 | 2 | 0.000164042 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.492126 | 0.656168 | 10.0002 | 0.164042 | 0.246063 | 0.410105 | 0.246063 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:567046 | Level 1 | 0.198016 | 1.1881 | 1082 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.64 | 250x450-250x150 | 0.738189 | 0.410105 | 6 | 36 | 6 | 6 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.82021 | 0.82021 | 1.1881 | 0.492126 | 1.47638 | 10 | 0.984252 | 0.410105 | 0.410105 | 0.246063 | 0.738189
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570433 | 2A02 | 0.164042 | 0.164042 | 8957 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:566878 | 1BC4 | 0.198016 | 0.792065 | 763 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.3 | 200x300-200x100 | 0.492126 | 0.328084 | 4 | 16 | 4 | 4 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.656168 | 0.656168 | 0.792065 | 0.328084 | 0.984252 | 10 | 0.656168 | 0.328084 | 0.328084 | 0.164042 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568679 | 1E18 | 0.246063 | 0.246063 | 5511 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569198 | 2C14 | 0.594049 | 0.198016 | 6229 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07045 | 350x300-200x350 | 0.491962 | 0.574147 | 1 | 1 | 0.998 | 1.002 | 3 | 9 | 3 | 3 | 0.000164042 | 0 | 10 | 0.492126 | 0.656168 | 1.14829 | 0.594049 | 1.14829 | 0.984252 | 9.99984 | 0.164042 | 0.328084 | 0.574147 | 0.574147 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567544 | 1B13 | 0.198016 | 0.396032 | 2350 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.79952 | 350x300-350x200 | 0.492126 | 0.574147 | 2 | 4 | 2 | 2 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.396032 | 0.656168 | 0.984252 | 10 | 0.328084 | 0.574147 | 0.574147 | 0.328084 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568290 | 1D07 | 0.0990081 | 0.198016 | 4832 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -0.860468 | 275x250-250x250 | 0.409941 | 0.451115 | 1 | 1 | 1 | 1 | 0.5 | 0.25 | 0.5 | 0.5 | 0.000164042 | 0 | 10 | 0.082021 | 0.82021 | 0.902231 | 0.0990081 | 0.82021 | 0.82021 | 9.99984 | 0 | 0.410105 | 0.451115 | 0.410105 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568621 | 1D12 | 0.164042 | 0.164042 | 5474 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:567248 | 1D25 | 0.594049 | 0.594049 | 1481 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.51893 | 300x300-150x450 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.47638 | 0.984252 | 10 | 0.492126 | 0.246063 | 0.492126 | 0.738189 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569233 | 2C12 | 0.198016 | 0.198016 | 6357 | Supply Air | Default Supply Air (cskender) | SR4-1 | Roof - Main | Level : Roof - Main | -1.27048 | 350x300-300x250 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.984252 | 1.14829 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.492126 | 0.574147 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569025 | 2C02 | 0.396032 | 0.594049 | 5742 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-400x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 1.31234 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.656168 | 0.492126 | 0.246063 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568613 | 1C02 | 0.246063 | 0.246063 | 5470 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567030 | 1D32 | 0.198016 | 0.594049 | 1063 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.35893 | 300x300-250x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 0.492126 | 0.246063 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568754 | 1AC4 | 0.246063 | 0.246063 | 5565 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567509 | 1B07 | 0.246063 | 0.246063 | 2292 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568436 | 1A16 | 0.164042 | 0.164042 | 5228 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567777 | 1DC7 | 0.246063 | 0.246063 | 3122 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:566755 | 1DC1 | 0.198016 | 0.198016 | 310 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.93 | 650x350-650x300 | 0.574147 | 1.06627 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 2.13255 | 2.13255 | 0.198016 | 0.984252 | 1.14829 | 10 | 0.164042 | 1.06627 | 1.06627 | 0.492126 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:569040 | 2A07 | 0.396032 | 0.594049 | 5763 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-400x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 1.31234 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.656168 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567191 | 1D16 | 0.594049 | 0.198016 | 1407 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.64 | 450x250-300x300 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 1.47638 | 0.984252 | 0.594049 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.738189 | 0.492126 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570507 | 1DC1 | 1.38611 | 0.198016 | 9176 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.79 | 650x250-300x300 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 7 | 49 | 7 | 7 | 0 | 0 | 10 | 1.14829 | 2.13255 | 0.984252 | 1.38611 | 0.82021 | 0.984252 | 10 | 0.164042 | 1.06627 | 0.492126 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570177 | 2BC1 | 0.198016 | 0.594049 | 8692 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-250x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 0.492126 | 0.246063 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568645 | 1D22 | 0.082021 | 0.082021 | 5490 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular Transition - Angle:45 Degree:45 Degree:570025 | 2DC2 | 0.594049 | 0.594049 | 8408 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-150x450 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.47638 | 0.984252 | 10 | 0.492126 | 0.246063 | 0.492126 | 0.738189 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570630 | 1D08 | 2.37619 | 0.198016 | 298 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.545 | 800x300-200x250 | 0.492126 | 1.31234 | 1 | 1 | 1 | 1 | 12 | 144 | 12 | 12 | 0 | 0 | 10 | 1.9685 | 0.656168 | 2.62467 | 2.37619 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.328084 | 1.31234 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569129 | 2A01 | 0.198016 | 0.198016 | 6108 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.73 | 250x350-250x300 | 0.574147 | 0.410105 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.82021 | 0.82021 | 0.198016 | 0.984252 | 1.14829 | 10 | 0.164042 | 0.410105 | 0.410105 | 0.492126 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:570634 | 1D02 | 2.37619 | 0.198016 | 315 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.545 | 800x300-200x250 | 0.492126 | 1.31234 | 1 | 1 | 1 | 1 | 12 | 144 | 12 | 12 | 0 | 0 | 10 | 1.9685 | 0.656168 | 2.62467 | 2.37619 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.328084 | 1.31234 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:566791 | 1DC3 | 0.198016 | 0.198016 | 465 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -1.27 | 300x200-250x150 | 0.328084 | 0.492126 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.410105 | 0.492126 | 0.246063 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:570532 | 1AC1 | 2.17818 | 0.594049 | 9234 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.454 | 800x300-250x150 | 0.492126 | 1.31234 | 3 | 9 | 3 | 3 | 11 | 121 | 11 | 11 | 0 | 0 | 10 | 1.80446 | 0.82021 | 2.62467 | 2.17818 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 1.31234 | 0.246063 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570236 | 2C17 | 0 | 0 | 8846 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-300ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 0; Num 7: 0; Num 6: 0; Num 10: 0; Num 1: 0; Length 8: 0; Length 7: 0; Length 6: 0; Length 5: 0; Length 4: 0; Half H0: 0.492126; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0; Delta 1: 0; W0: 0.984252; Radius: 0.492126; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.492126; Lining H0: 0.984252; Length01: 0.246063; Insulation W0: 0.984252; Insulation Radius: 0.492126; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.984252
M_Rectangular Transition - Angle:45 Degree:45 Degree:566746 | 1E23 | 0.198016 | 0.198016 | 279 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.755 | 200x200-200x150 | 0.328084 | 0.328084 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.656168 | 0.656168 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.328084 | 0.328084 | 0.246063 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:569978 | 2D11 | 0.198016 | 0.594049 | 8355 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568475 | 1C10 | 0.198016 | 0.594049 | 5289 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.35893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Round Transition - Angle:45 Degree:45 Degree:569082 | 2AC4 | 0.082021 | 0.082021 | 5935 | Supply Air | Mechanical Supply Air 2 | SD4-1 | Roof - Main | Level : Roof - Main | -1.08 | 350ø-300ø | 0.574147 | 0.574147 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0478456; OffsetHeightTemp: 0.0478456; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.492126; R0: 0.574147; Lining Radius 1: 0.492126; Lining Radius 0: 0.574147; Insulation Radius 1: 0.492126; Insulation Radius 0: 0.574147; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular Transition - Angle:45 Degree:45 Degree:569122 | 2A02 | 0.198016 | 0.792065 | 6094 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.73 | 350x350-350x150 | 0.574147 | 0.574147 | 4 | 16 | 4 | 4 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.792065 | 0.492126 | 1.14829 | 10 | 0.656168 | 0.574147 | 0.574147 | 0.246063 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:570192 | 2D04-A | 2.17818 | 0.396032 | 8711 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 4 | 850x200-300x300 | 0.492126 | 0.492126 | 2 | 4 | 2 | 2 | 11 | 121 | 11 | 11 | 0 | 0 | 10 | 1.80446 | 2.78871 | 0.984252 | 2.17818 | 0.656168 | 0.984252 | 10 | 0.328084 | 1.39436 | 0.492126 | 0.328084 | 0.492126
M_Round Transition - Angle:45 Degree:45 Degree:569084 | 2A14 | 0.082021 | 0.082021 | 5947 | Supply Air | Mechanical Supply Air 2 | SD4-1 | Roof - Main | Level : Roof - Main | -1.08 | 300ø-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0410105; OffsetHeightTemp: 0.0410105; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.410105; R0: 0.492126; Lining Radius 1: 0.410105; Lining Radius 0: 0.492126; Insulation Radius 1: 0.410105; Insulation Radius 0: 0.492126; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570422 | 2AC2 | 0.164042 | 0.164042 | 8950 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567634 | 1D32 | 0.246063 | 0.246063 | 2646 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568672 | 1EC3 | 0.246063 | 0.246063 | 5507 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
