Properties of the parts of a building model (IFC2X3), part 281 of 295

# IfcFlowSegment: Round Duct:Taps / Short Radius:569487
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569489
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569489
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.242724 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.3409 m; Top Elevation: 3.6186 m; Size Lock: no; Loss Coefficient: 0.0272855; Hydraulic Diameter: 0.492126; Section: 70; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.114381 m2
PSet_Revit_Identity Data - Mark: 1459
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 0.884359; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.56557 m; Start Offset: 3.56557 m; End Offset: 3.39393 m; Slope: 1
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569492
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569492
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 0.466946; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5095 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.0455328; Hydraulic Diameter: 0.656168; Section: 82; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.319466 m2
PSet_Revit_Identity Data - Mark: 1461
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.508445 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569494
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569494
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1466
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5095 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.0544815; Hydraulic Diameter: 0.656168; Section: 80; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.382251 m2
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.608371 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 0.558716; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569496
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569496
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5345 m; Top Elevation: 3.6845 m; Size Lock: no; Loss Coefficient: 0.0660842; Hydraulic Diameter: 0.492126; Section: 64; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.277026 m2
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.587868 m
PSet_Revit_Identity Data - Mark: 1477
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 2.14188; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569498
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569498
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.70615 m
PSet_Revit_Identity Data - Mark: 1478
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.35 m; Start Offset: 3.35 m; End Offset: 3.35 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.275 m; Top Elevation: 3.425 m; Size Lock: no; Loss Coefficient: 0.0793807; Hydraulic Diameter: 0.492126; Section: 64; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.332765 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 2.57284; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569499
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569499
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.3409 m; Top Elevation: 3.6186 m; Size Lock: no; Loss Coefficient: 0.0272855; Hydraulic Diameter: 0.492126; Section: 64; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.114381 m2
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.242724 m
PSet_Revit_Identity Data - Mark: 1479
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 0.884359; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.56557 m; Start Offset: 3.56557 m; End Offset: 3.39393 m; Slope: 1
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569504
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569504
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 1.16605 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5345 m; Top Elevation: 3.6845 m; Size Lock: no; Loss Coefficient: 0.13108; Hydraulic Diameter: 0.492126; Section: 46; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.549488 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1482
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 4.24847; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569506
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569506
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.417618 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5345 m; Top Elevation: 3.6845 m; Size Lock: no; Loss Coefficient: 0.0469459; Hydraulic Diameter: 0.492126; Section: 46; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.196798 m2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 1.52158; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1483
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569508
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569508
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.35 m; Start Offset: 3.35 m; End Offset: 3.35 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1484
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.275 m; Top Elevation: 3.425 m; Size Lock: no; Loss Coefficient: 0.0145102; Hydraulic Diameter: 0.492126; Section: 46; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.0608268 m2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 0.470294; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.129079 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569509
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569509
PSet_Revit_Identity Data - Mark: 1485
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.242724 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.3409 m; Top Elevation: 3.6186 m; Size Lock: no; Loss Coefficient: 0.0272855; Hydraulic Diameter: 0.492126; Section: 46; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.114381 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 0.884359; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.56557 m; Start Offset: 3.56557 m; End Offset: 3.39393 m; Slope: 1
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569525
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569525
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1495
PSet_Revit_Mechanical - Airflow - Flow: 75.0437; Additional Flow: 0; Velocity: 55.4797; Friction: 0.525653; Pressure Drop: 11.0718; Velocity Pressure: 52.4088; Reynolds number: 450701
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Size Lock: no; Loss Coefficient: 0.211259; Hydraulic Diameter: 1.31234; Section: 207; Insulation Thickness: 0; Lining Thickness: 0; Area: 8.06761 m2
PSet_Revit_Dimensions - Size: 400ø; Diameter: 1.31234; Length: 6.42 m
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569527
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569527
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 1.63893 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.475 m; Top Elevation: 3.725 m; Size Lock: no; Loss Coefficient: 0.0943088; Hydraulic Diameter: 0.82021; Section: 217; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.28722 m2
PSet_Revit_Mechanical - Airflow - Flow: 30.0175; Additional Flow: 0; Velocity: 56.8112; Friction: 0.963851; Pressure Drop: 5.1827; Velocity Pressure: 54.9546; Reynolds number: 288448
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1496
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569529
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569529
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5 m; Top Elevation: 3.7 m; Size Lock: no; Loss Coefficient: 0.0158074; Hydraulic Diameter: 0.656168; Section: 399; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.125482 m2
PSet_Revit_Identity Data - Mark: 1497
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 0.530206; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.199712 m
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569531
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569531
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.60002 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 3.74289; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Identity Data - Mark: 1498
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 1.40983 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5 m; Top Elevation: 3.70002 m; Size Lock: no; Loss Coefficient: 0.111589; Hydraulic Diameter: 0.656168; Section: 399; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.885821 m2
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569536
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569536
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1500
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 1.02093 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.475 m; Top Elevation: 3.725 m; Size Lock: no; Loss Coefficient: 0.0676988; Hydraulic Diameter: 0.82021; Section: 216; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.801834 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 0.93009; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569537
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569537
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.46552 m; Top Elevation: 3.71552 m; Size Lock: no; Loss Coefficient: 0.00959911; Hydraulic Diameter: 0.82021; Section: 216; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.113693 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.59052 m; Start Offset: 3.59052 m; End Offset: 3.59052 m; Slope: 0
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.144759 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1501
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 0.131879; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569538
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569538
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.214249 m
PSet_Revit_Identity Data - Mark: 1502
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.46585 m; Top Elevation: 3.72467 m; Size Lock: no; Loss Coefficient: 0.0142071; Hydraulic Diameter: 0.82021; Section: 216; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.168271 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 0.195186; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.59074 m; Start Offset: 3.59074 m; End Offset: 3.59978 m; Slope: 0.0422222
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569541
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569541
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5 m; Top Elevation: 3.70002 m; Size Lock: no; Loss Coefficient: 0.0730925; Hydraulic Diameter: 0.656168; Section: 206; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.580224 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.60002 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 2.45164; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.923455 m
PSet_Revit_Identity Data - Mark: 1503
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569542
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569542
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 78.9045; Friction: 3.21519; Pressure Drop: 10.8135; Velocity Pressure: 106.008; Reynolds number: 240374
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 1.02512 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.525 m; Top Elevation: 3.675 m; Size Lock: no; Loss Coefficient: 0.102006; Hydraulic Diameter: 0.492126; Section: 402; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.483076 m2
PSet_Revit_Identity Data - Mark: 1504
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569543
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569543
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 1.41135 m
PSet_Revit_Identity Data - Mark: 1505
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.475 m; Top Elevation: 3.725 m; Size Lock: no; Loss Coefficient: 0.093588; Hydraulic Diameter: 0.82021; Section: 259; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.10847 m2
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 1.28577; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569544
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569544
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 0.564836; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.475 m; Top Elevation: 3.725 m; Size Lock: no; Loss Coefficient: 0.0411129; Hydraulic Diameter: 0.82021; Section: 250; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.486947 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.62 m
PSet_Revit_Identity Data - Mark: 1506
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569545
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569545
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 1.30277 m
PSet_Revit_Identity Data - Mark: 1507
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.475 m; Top Elevation: 3.725 m; Size Lock: no; Loss Coefficient: 0.0863879; Hydraulic Diameter: 0.82021; Section: 405; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.02319 m2
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 1.18685; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569546
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569546
