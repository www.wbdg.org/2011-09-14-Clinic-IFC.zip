Properties of the parts of a building model (IFC2X3), part 46 of 295

# IfcFlowFitting: Transition - Generic (1536)
Name (M_Transition - Generic:Transition - Generic:Transition - Generic:...) | In | Mark | System Type | System Name | Width Offset | Visibility 3 | Visibility 2 | Visibility 1 | Max Fitting Outside Diameter 12 | Height Offset | Fitting Outside Radius 2 = Insulation Radius 2 | Fitting Outside Radius 1 = Insulation Radius 1 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level | Host | Offset (m) | Tick Size 2 | Tick Size 1 | Nominal Radius 2 | Nominal Radius 1 | Nominal Diameter 2 | Nominal Diameter 1 | Length | Fitting Outside Diameter 2 | Fitting Outside Diameter 1 | Size | OffsetHeight | OffsetWidth
1003237 | 1E20 | 10311 | Fire Protection Wet | Fire Protection | 9.9899 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0555184
717227 | 1C02 | 9323 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1013353 | 1CC1 | 10791 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0188 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0844054 | 0.0656168
1013690 | 1C06 | 10887 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1049664 | 2D18 | 12412 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1084788 | 2C17 | 14580 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.610319 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
708299 | TOF Footing | 8364 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
703361 | TOF Footing | 7752 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.330156 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
702764 | TOF Footing | 7690 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1084994 | 1D16 | 14598 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
710966 | TOF Footing | 8666 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0364583 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0375 | 0.0328084 | 0.0410105 | 0.0656168 | 0.082021 | 0.0234375 | 0.0729167 | 0.09375 | 25 mmø-20 mmø | 0.0410105 | 0.0410105
699608 | 1D16 | 7339 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.47619 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
1027322 | 1B23 | 11364 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1005020 | 1E30 | 10356 | Fire Protection Wet | Fire Protection | 9.99685 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0624694
707526 | TOF Footing | 8255 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
700596 | TOF Footing | 7422 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
1079728 | 1D32 | 14113 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.610319 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
706131 | TOF Footing | 8069 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1026835 | 1E05 | 11192 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1062707 | 1AC2 | 13479 | Fire Protection Wet | Fire Protection | 10 | yes | no | no | 0.510417 | 10 | 0.255208 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.204167 | 0.0541667 | 0.246063 | 0.0656168 | 0.492126 | 0.131234 | 0.127604 | 0.510417 | 0.135417 | 150 mmø-40 mmø | 0.0656168 | 0.0656168
1012982 | 1D22 | 10643 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1012871 | 1DC1 | 10607 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0027 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0682828 | 0.0656168
713302 | 1B04 | 8926 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.43 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
692983 | Level 2 | 6583 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.2 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1083237 | 2A05 | 14437 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.2 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
665761 | Level 2 | 4560 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 3.05952 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
635009 | TOF Footing | 1677 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.260417 | 10 | 0.0885417 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.447612 | 0.0708333 | 0.104167 | 0.082021 | 0.131234 | 0.164042 | 0.262467 | 0.0651042 | 0.177083 | 0.260417 | 80 mmø-50 mmø | 0.131234 | 0.131234
636441 | TOF Footing | 1889 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
700573 | TOF Footing | 7417 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1079496 | 1D28 | 14110 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.134131 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
1012454 | 1E09 | 10499 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1081190 | TOF Footing | 14256 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.135417 | 10 | 0.0677083 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0541667 | 0.0458333 | 0.0656168 | 0.0524934 | 0.131234 | 0.104987 | 0.0338542 | 0.135417 | 0.114583 | 40 mmø-32 mmø | 0.0524934 | 0.0524934
1126238 | 1C13 | 15454 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.35 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
635703 | TOF Footing | 1794 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.34375 | 10 | 0.130208 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.104167 | 0.1375 | 0.131234 | 0.164042 | 0.262467 | 0.328084 | 0.0859375 | 0.260417 | 0.34375 | 100 mmø-80 mmø | 0.164042 | 0.164042
701545 | TOF Footing | 7524 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
635823 | TOF Footing | 1808 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
658544 | Level 1 | 3715 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.62311 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
697029 | 1A16 | 6993 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
1026744 | 1DC8 | 11172 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
710486 | TOF Footing | 8626 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1014087 | 1E26 | 11031 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
705726 | TOF Footing | 8032 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.25 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1012997 | 1DC1 | 10651 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1081977 | 2C06 | 14301 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.260417 | 10 | 0.0572917 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.2 | 0.0458333 | 0.104167 | 0.0524934 | 0.131234 | 0.104987 | 0.262467 | 0.0651042 | 0.114583 | 0.260417 | 80 mmø-32 mmø | 0.131234 | 0.131234
639410 | TOF Footing | 2210 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.130208 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.501123 | 0.104167 | 0.1375 | 0.131234 | 0.164042 | 0.262467 | 0.328084 | 0.0859375 | 0.260417 | 0.34375 | 100 mmø-80 mmø | 0.164042 | 0.164042
634236 | 1B03 | 1530 | Sanitary | Default Sanitary (cskender) | 10.0018 | no | no | yes | 0.114583 | 10 | 0.0572917 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.231963 | 0.0458333 | 0.0458333 | 0.0524934 | 0.0524934 | 0.104987 | 0.104987 | 0.0286458 | 0.114583 | 0.114583 | 32 mmø-32 mmø | 0.0524934 | 0.0543347
1014031 | 1E33 | 11011 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10.0254 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0909817 | 0.0656168
710908 | TOF Footing | 8663 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
707587 | TOF Footing | 8258 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
1051213 | 2D02 | 12828 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1052678 | 2AC3 | 13182 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1081476 | 2C14 | 14272 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.260417 | 10 | 0.0572917 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.2 | 0.0458333 | 0.104167 | 0.0524934 | 0.131234 | 0.104987 | 0.262467 | 0.0651042 | 0.114583 | 0.260417 | 80 mmø-32 mmø | 0.131234 | 0.131234
1082161 | 2C09 | 14319 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.610319 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
710909 | TOF Footing | 8664 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1098032 | TOF Footing | 14884 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
713160 | 1B11 | 8909 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.43 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1081534 | Level 2 | 14288 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.3 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
634528 | TOF Footing | 1599 | Sanitary | Default Sanitary (cskender) | 10 | yes | no | no | 0.177083 | 10 | 0.0885417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0708333 | 0.0458333 | 0.082021 | 0.0524934 | 0.164042 | 0.104987 | 0.0442708 | 0.177083 | 0.114583 | 50 mmø-32 mmø | 0.0524934 | 0.0524934
641981 | TOF Footing | 2525 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.460312 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
1081515 | 2C14 | 14278 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.610319 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
1076761 | Level 1 | 13895 | Domestic Hot Water | Domestic Hot Water 1 | 9.99843 | no | no | yes | 0.0520833 | 10 | 0.0260417 | 0.0260417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.2 | 0.0208333 | 0.0208333 | 0.0246063 | 0.0246063 | 0.0492126 | 0.0492126 | 0.0130208 | 0.0520833 | 0.0520833 | 15 mmø-15 mmø | 0.0246063 | 0.023041
1081253 | TOF Footing | 14263 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1051186 | 2BC1 | 12824 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1122533 | 2A09 | 15173 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
1125752 | 1E33 | 15392 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.35 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1051127 | 2B10 | 12808 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.95801 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
634373 | Level 1 | 1557 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.34375 | 10 | 0.130208 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.232932 | 0.104167 | 0.1375 | 0.131234 | 0.164042 | 0.262467 | 0.328084 | 0.0859375 | 0.260417 | 0.34375 | 100 mmø-80 mmø | 0.164042 | 0.164042
639370 | TOF Footing | 2205 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.177083 | 10 | 0.0885417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.501123 | 0.0708333 | 0.0458333 | 0.082021 | 0.0524934 | 0.164042 | 0.104987 | 0.0442708 | 0.177083 | 0.114583 | 50 mmø-32 mmø | 0.0524934 | 0.0524934
716509 | 1C13 | 9244 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.35 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
698812 | 1DC3 | 7212 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0364583 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0291667 | 0.0541667 | 0.0328084 | 0.0656168 | 0.0656168 | 0.131234 | 0.0338542 | 0.0729167 | 0.135417 | 40 mmø-20 mmø | 0.0656168 | 0.0656168
710097 | TOF Footing | 8579 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
1030948 | 2C13 | 11878 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
1049684 | 2D18 | 12416 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.177083 | 10 | 0.046875 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0375 | 0.0708333 | 0.0246063 | 0.0656168 | 0.082021 | 0.131234 | 0.0442708 | 0.09375 | 0.177083 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
634796 | TOF Footing | 1646 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
701546 | TOF Footing | 7525 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
656064 | Level 2 | 3508 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.34375 | 10 | 0.0885417 | 0.171875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 5.51047 | 0.0708333 | 0.1375 | 0.082021 | 0.164042 | 0.164042 | 0.328084 | 0.0859375 | 0.177083 | 0.34375 | 100 mmø-50 mmø | 0.164042 | 0.164042
1070336 | 2D05 | 13727 | Hydronic Return | Hydronic Return 1 | 10 | no | yes | no | 0.510417 | 10 | 0.171875 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 4 | 0.1375 | 0.204167 | 0.164042 | 0.246063 | 0.328084 | 0.492126 | 0.127604 | 0.34375 | 0.510417 | 150 mmø-100 mmø | 0.246063 | 0.246063
1016369 | 1DC4 | 11043 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
643622 | TOF Footing | 2753 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.460312 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
1013337 | 1D16 | 10783 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1062825 | 1CC1 | 13504 | Fire Protection Wet | Fire Protection | 10 | yes | no | no | 0.135417 | 10 | 0.0677083 | 0.0260417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.0208333 | 0.0656168 | 0.0246063 | 0.131234 | 0.0492126 | 0.0338542 | 0.135417 | 0.0520833 | 40 mmø-15 mmø | 0.0246063 | 0.0246063
1013012 | 1DC1 | 10659 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.95166 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
724171 | TOF Footing | 9757 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.4 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1062784 | 1C04 | 13494 | Fire Protection Wet | Fire Protection | 10 | yes | no | no | 0.135417 | 10 | 0.0677083 | 0.0260417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.0208333 | 0.0656168 | 0.0246063 | 0.131234 | 0.0492126 | 0.0338542 | 0.135417 | 0.0520833 | 40 mmø-15 mmø | 0.0246063 | 0.0246063
1013067 | 1DC1 | 10679 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
709697 | TOF Footing | 8534 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1031094 | 2D05 | 11884 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
1012419 | 1E25 | 10495 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
700512 | 1E01 | 7415 | Domestic Hot Water | Domestic Hot Water 1 | 10 | yes | no | no | 0.0729167 | 10 | 0.0364583 | 0.0260417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.2 | 0.0291667 | 0.0208333 | 0.0328084 | 0.0246063 | 0.0656168 | 0.0492126 | 0.0182292 | 0.0729167 | 0.0520833 | 20 mmø-15 mmø | 0.0246063 | 0.0246063
694771 | 1C01 | 6734 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
703136 | TOF Footing | 7727 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
713328 | 1B10 | 8931 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1029812 | 2BC2 | 11791 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
1029980 | 2BC1 | 11800 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
713001 | 1B09 | 8894 | Domestic Hot Water | Domestic Hot Water 1 | 10 | yes | no | no | 0.114583 | 10 | 0.0572917 | 0.0260417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.43 | 0.0458333 | 0.0208333 | 0.0524934 | 0.0246063 | 0.104987 | 0.0492126 | 0.0286458 | 0.114583 | 0.0520833 | 32 mmø-15 mmø | 0.0246063 | 0.0246063
1082232 | 2C04 | 14337 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.2 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
1125810 | 1E33 | 15394 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
1031044 | 2C12 | 11882 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
703256 | TOF Footing | 7741 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1013373 | 1C17 | 10795 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
1013710 | 1C05 | 10891 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
713043 | 1B04 | 8902 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0260417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.43 | 0.0208333 | 0.0541667 | 0.0246063 | 0.0656168 | 0.0492126 | 0.131234 | 0.0338542 | 0.0520833 | 0.135417 | 40 mmø-15 mmø | 0.0656168 | 0.0656168
715528 | 1C02 | 9143 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
639221 | TOF Footing | 2185 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.501123 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
1085074 | 2C17 | 14613 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.610319 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
1131735 | 1DC4 | 15641 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
1131789 | 1DC4 | 15649 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
706001 | TOF Footing | 8055 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0260417 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0375 | 0.0246063 | 0.0410105 | 0.0492126 | 0.082021 | 0.0234375 | 0.0520833 | 0.09375 | 25 mmø-15 mmø | 0.0410105 | 0.0410105
634601 | Level 1 | 1613 | Sanitary | Default Sanitary (cskender) | 10 | yes | no | no | 0.34375 | 10 | 0.171875 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0 | 0.1375 | 0.0458333 | 0.164042 | 0.0524934 | 0.328084 | 0.104987 | 0.0859375 | 0.34375 | 0.114583 | 100 mmø-32 mmø | 0.0524934 | 0.0524934
711575 | TOF Footing | 8762 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0260417 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0375 | 0.0246063 | 0.0410105 | 0.0492126 | 0.082021 | 0.0234375 | 0.0520833 | 0.09375 | 25 mmø-15 mmø | 0.0410105 | 0.0410105
1083991 | 1A16 | 14516 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.177083 | 10 | 0.0885417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.0708333 | 0.0541667 | 0.082021 | 0.0656168 | 0.164042 | 0.131234 | 0.0442708 | 0.177083 | 0.135417 | 50 mmø-40 mmø | 0.0656168 | 0.0656168
706567 | 1BC2 | 8108 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
703296 | TOF Footing | 7746 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.35 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
710487 | TOF Footing | 8627 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
710698 | 1D18 | 8650 | Domestic Hot Water | Domestic Hot Water 1 | 10 | yes | no | no | 0.0729167 | 10 | 0.0364583 | 0.0260417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.2 | 0.0291667 | 0.0208333 | 0.0328084 | 0.0246063 | 0.0656168 | 0.0492126 | 0.0182292 | 0.0729167 | 0.0520833 | 20 mmø-15 mmø | 0.0246063 | 0.0246063
1029979 | 2BC1 | 11799 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 2.985 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
634827 | TOF Footing | 1660 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.260417 | 10 | 0.0677083 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0541667 | 0.104167 | 0.0656168 | 0.131234 | 0.131234 | 0.262467 | 0.0651042 | 0.135417 | 0.260417 | 80 mmø-40 mmø | 0.131234 | 0.131234
636344 | TOF Footing | 1876 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.260417 | 10 | 0.0885417 | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0708333 | 0.104167 | 0.082021 | 0.131234 | 0.164042 | 0.262467 | 0.0651042 | 0.177083 | 0.260417 | 80 mmø-50 mmø | 0.131234 | 0.131234
708358 | TOF Footing | 8369 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.25 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1002651 | 1CC3 | 10274 | Fire Protection Wet | Fire Protection | 10 | no | yes | no | 0.510417 | 10 | 0.0677083 | 0.255208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 2.985 | 0.0541667 | 0.204167 | 0.0656168 | 0.246063 | 0.131234 | 0.492126 | 0.127604 | 0.135417 | 0.510417 | 150 mmø-40 mmø | 0.246063 | 0.246063
1085191 | 2C17 | 14619 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.438319 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
713112 | Level 1 | 8906 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
1084568 | 2C10 | 14576 | Undefined | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.610319 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
712964 | 1B04 | 8888 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0260417 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.43 | 0.0208333 | 0.0375 | 0.0246063 | 0.0410105 | 0.0492126 | 0.082021 | 0.0234375 | 0.0520833 | 0.09375 | 25 mmø-15 mmø | 0.0410105 | 0.0410105
1126525 | 1E01 | 15478 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
712871 | 1B03 | 8880 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
717258 | 1C10 | 9327 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.114583 | 10 | 0.0260417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0458333 | 0.0246063 | 0.0524934 | 0.0492126 | 0.104987 | 0.0286458 | 0.0520833 | 0.114583 | 32 mmø-15 mmø | 0.0524934 | 0.0524934
705944 | TOF Footing | 8051 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.25 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
713303 | 1B04 | 8927 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.43 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
635395 | TOF Footing | 1775 | Sanitary | Default Sanitary (cskender) | 10 | no | yes | no | 0.177083 | 10 | 0.0572917 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0458333 | 0.0708333 | 0.0524934 | 0.082021 | 0.104987 | 0.164042 | 0.0442708 | 0.114583 | 0.177083 | 50 mmø-32 mmø | 0.082021 | 0.082021
712901 | 1B03 | 8882 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
1086489 | Level 1 | 14704 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.0520833 | 10 | 0.0208333 | 0.0260417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | 0.908719 | 0.0166667 | 0.0208333 | 0.0164042 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0130208 | 0.0416667 | 0.0520833 | 15 mmø-10 mmø | 0.0246063 | 0.0246063
706132 | TOF Footing | 8070 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
635285 | TOF Footing | 1742 | Sanitary | Default Sanitary (cskender) | 10 | yes | no | no | 0.177083 | 10 | 0.0885417 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.326987 | 0.0708333 | 0.0541667 | 0.082021 | 0.0656168 | 0.164042 | 0.131234 | 0.0442708 | 0.177083 | 0.135417 | 50 mmø-40 mmø | 0.0656168 | 0.0656168
713634 | 1D32 | 8963 | Domestic Hot Water | Domestic Hot Water 1 | 10 | yes | no | no | 0.0729167 | 10 | 0.0364583 | 0.0260417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.35 | 0.0291667 | 0.0208333 | 0.0328084 | 0.0246063 | 0.0656168 | 0.0492126 | 0.0182292 | 0.0729167 | 0.0520833 | 20 mmø-15 mmø | 0.0246063 | 0.0246063
698806 | 1DC3 | 7210 | Domestic Cold Water | Domestic Cold Water 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0364583 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0291667 | 0.0541667 | 0.0328084 | 0.0656168 | 0.0656168 | 0.131234 | 0.0338542 | 0.0729167 | 0.135417 | 40 mmø-20 mmø | 0.0656168 | 0.0656168
712900 | 1B03 | 8881 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
641366 | TOF Footing | 2461 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0677083 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -5.03031 | 0.0541667 | 0.0708333 | 0.0656168 | 0.082021 | 0.131234 | 0.164042 | 0.0442708 | 0.135417 | 0.177083 | 50 mmø-40 mmø | 0.082021 | 0.082021
1085892 | Level 1 | 14661 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
1099023 | 1D07 | 14984 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.260417 | 10 | 0.130208 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.104167 | 0.0541667 | 0.131234 | 0.0656168 | 0.262467 | 0.131234 | 0.0651042 | 0.260417 | 0.135417 | 80 mmø-40 mmø | 0.0656168 | 0.0656168
1085128 | 1D16 | 14617 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.0729167 | 10 | 0.0260417 | 0.0364583 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.4 | 0.0208333 | 0.0291667 | 0.0246063 | 0.0328084 | 0.0492126 | 0.0656168 | 0.0182292 | 0.0520833 | 0.0729167 | 20 mmø-15 mmø | 0.0328084 | 0.0328084
1083280 | 2A05 | 14439 | Sanitary | Sanitary 1 | 10 | no | yes | no | 0.135417 | 10 | 0.0572917 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | 0.610319 | 0.0458333 | 0.0541667 | 0.0524934 | 0.0656168 | 0.104987 | 0.131234 | 0.0338542 | 0.114583 | 0.135417 | 40 mmø-32 mmø | 0.0656168 | 0.0656168
1083676 | 1A03 | 14487 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.34375 | 10 | 0.171875 | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.6882 | 0.1375 | 0.0541667 | 0.164042 | 0.0656168 | 0.328084 | 0.131234 | 0.0859375 | 0.34375 | 0.135417 | 100 mmø-40 mmø | 0.0656168 | 0.0656168
710967 | TOF Footing | 8667 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.09375 | 10 | 0.0364583 | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0375 | 0.0328084 | 0.0410105 | 0.0656168 | 0.082021 | 0.0234375 | 0.0729167 | 0.09375 | 25 mmø-20 mmø | 0.0410105 | 0.0410105
703322 | TOF Footing | 7750 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
713417 | 1B10 | 8943 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0260417 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 2 | Level : Level 2 | -1.5 | 0.0208333 | 0.0708333 | 0.0246063 | 0.082021 | 0.0492126 | 0.164042 | 0.0442708 | 0.0520833 | 0.177083 | 50 mmø-15 mmø | 0.082021 | 0.082021
639952 | TOF Footing | 2307 | Sanitary | Sanitary 1 | 10 | yes | no | no | 0.177083 | 10 | 0.0885417 | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.5 | 0.0708333 | 0.0458333 | 0.082021 | 0.0524934 | 0.164042 | 0.104987 | 0.0442708 | 0.177083 | 0.114583 | 50 mmø-32 mmø | 0.0524934 | 0.0524934
710739 | TOF Footing | 8653 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
703174 | TOF Footing | 7733 | Domestic Hot Water | Domestic Hot Water 1 | 10 | no | yes | no | 0.177083 | 10 | 0.0364583 | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Level 1 | Level : Level 1 | -0.3 | 0.0291667 | 0.0708333 | 0.0328084 | 0.082021 | 0.0656168 | 0.164042 | 0.0442708 | 0.0729167 | 0.177083 | 50 mmø-20 mmø | 0.082021 | 0.082021
