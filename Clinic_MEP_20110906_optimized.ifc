Properties of the parts of a building model (IFC2X3), part 52 of 295

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568739
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568742
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568742
PSet_Revit_Identity Data - Mark: 110
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.115179; Hydraulic Diameter: 0.82021; Section: 132; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.483809; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.40109 m
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568744
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568744
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Identity Data - Mark: 111
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.05757 m
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.106866; Hydraulic Diameter: 0.656168; Section: 130; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.09592; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568747
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568747
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Identity Data - Mark: 112
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 4.25418; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.131256; Hydraulic Diameter: 0.492126; Section: 123; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.978128 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568749
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568749
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Mechanical - Airflow - Flow: -9.88811; Additional Flow: 0; Velocity: 29.2411; Friction: 0.4372; Pressure Drop: 1.643; Velocity Pressure: 14.5587; Reynolds number: 118773
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.14544 m
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 113
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.112854; Hydraulic Diameter: 0.656168; Section: 125; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568751
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568751
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.120655; Hydraulic Diameter: 0.656168; Section: 93; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Identity Data - Mark: 114
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.23734; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.19404 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568753
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568753
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.130389; Hydraulic Diameter: 0.492126; Section: 95; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 4.22609; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.971667 m
PSet_Revit_Identity Data - Mark: 115
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568755
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568755
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.5263; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.47289 m
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.148832; Hydraulic Diameter: 0.656168; Section: 88; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 116
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568757
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568757
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 6.72741; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.54677 m
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.207563; Hydraulic Diameter: 0.492126; Section: 99; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Identity Data - Mark: 117
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568759
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568759
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 119
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.41652; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.138128; Hydraulic Diameter: 0.656168; Section: 107; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.36696 m
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568761
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568761
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.136465; Hydraulic Diameter: 0.656168; Section: 583; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.3505 m
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Identity Data - Mark: 120
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.39947; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568763
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568763
PSet_Revit_Identity Data - Mark: 121
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.30826 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.107547; Hydraulic Diameter: 0.82021; Section: 77; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.451752; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568765
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568765
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.092712; Hydraulic Diameter: 0.82021; Section: 67; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.389438; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.1278 m
PSet_Revit_Identity Data - Mark: 122
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568768
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568768
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.05161 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.106263; Hydraulic Diameter: 0.656168; Section: 65; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.08974; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 123
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568770
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568770
PSet_Revit_Identity Data - Mark: 124
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.137606; Hydraulic Diameter: 0.82021; Section: 79; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.67391 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.578015; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568773
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568773
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.109158; Hydraulic Diameter: 0.656168; Section: 151; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Identity Data - Mark: 128
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.08026 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.11944; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568776
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568776
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.107699; Hydraulic Diameter: 0.492126; Section: 391; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Identity Data - Mark: 129
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 3.49068; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.802582 m
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568779
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568779
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.1247; Hydraulic Diameter: 0.82021; Section: 389; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Identity Data - Mark: 130
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.523805; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.51692 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568781
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568781
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.131925; Hydraulic Diameter: 0.492126; Section: 384; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 4.27585; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 131
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.98311 m
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568784
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568784
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.118118; Hydraulic Diameter: 0.492126; Section: 379; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 0.880221 m
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 3.82836; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Identity Data - Mark: 132
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568787
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568787
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 133
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.125835; Hydraulic Diameter: 0.82021; Section: 405; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.528573; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.53073 m
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568789
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568789
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.587668; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Identity Data - Mark: 134
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.70187 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.139904; Hydraulic Diameter: 0.82021; Section: 407; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568791
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568791
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.55843 m
PSet_Revit_Identity Data - Mark: 135
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.209127; Hydraulic Diameter: 0.492126; Section: 112; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 6.7781; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568793
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568793
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 136
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.72887; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.168586; Hydraulic Diameter: 0.656168; Section: 201; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.66838 m
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568796
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568796
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.27522 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.32146; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Identity Data - Mark: 137
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.128858; Hydraulic Diameter: 0.656168; Section: 203; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568798
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568798
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.133726; Hydraulic Diameter: 0.656168; Section: 472; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.37138; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 138
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.32339 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:568801
In: Level 1
Type - ElementType: Flex Duct Round:Flex Duct - Round:568801
PSet_Revit_Constraints - Reference Level: Level 1
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.06371 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 139
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Size Lock: no; Loss Coefficient: 0.107486; Hydraulic Diameter: 0.656168; Section: 435; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.10229; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
