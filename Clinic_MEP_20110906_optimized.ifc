Properties of the parts of a building model (IFC2X3), part 282 of 295

# IfcFlowSegment: Round Duct:Taps / Short Radius:569546
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.525 m; Top Elevation: 3.675 m; Size Lock: no; Loss Coefficient: 0.137256; Hydraulic Diameter: 0.492126; Section: 187; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.650009 m2
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 1.37936 m
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 78.9045; Friction: 3.21519; Pressure Drop: 14.5502; Velocity Pressure: 106.008; Reynolds number: 240374
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1508
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569547
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569547
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.475 m; Top Elevation: 3.725 m; Size Lock: no; Loss Coefficient: 0.0591989; Hydraulic Diameter: 0.82021; Section: 172; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.70116 m2
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.892745 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 0.813313; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Identity Data - Mark: 1509
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569548
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569548
PSet_Revit_Dimensions - Size: 400ø; Diameter: 1.31234; Length: 2.29707 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1510
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Size Lock: no; Loss Coefficient: 0.0707872; Hydraulic Diameter: 1.31234; Section: 197; Insulation Thickness: 0; Lining Thickness: 0; Area: 2.88658 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 105.061; Additional Flow: 0; Velocity: 77.6716; Friction: 0.964842; Pressure Drop: 7.27135; Velocity Pressure: 102.721; Reynolds number: 630981
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569549
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569549
PSet_Revit_Mechanical - Airflow - Flow: 105.061; Additional Flow: 0; Velocity: 77.6716; Friction: 0.964842; Pressure Drop: 0.405448; Velocity Pressure: 102.721; Reynolds number: 630981
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 400ø; Diameter: 1.31234; Length: 0.128084 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.3905 m; Top Elevation: 3.7905 m; Size Lock: no; Loss Coefficient: 0.00394707; Hydraulic Diameter: 1.31234; Section: 197; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.160955 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.5905 m; Start Offset: 3.5905 m; End Offset: 3.5905 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1511
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569550
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569550
PSet_Revit_Identity Data - Mark: 1512
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.39065 m; Top Elevation: 3.79985 m; Size Lock: no; Loss Coefficient: 0.0128182; Hydraulic Diameter: 1.31234; Section: 197; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.522703 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 400ø; Diameter: 1.31234; Length: 0.415954 m
PSet_Revit_Mechanical - Airflow - Flow: 105.061; Additional Flow: 0; Velocity: 77.6716; Friction: 0.964842; Pressure Drop: 1.3167; Velocity Pressure: 102.721; Reynolds number: 630981
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.5906 m; Start Offset: 3.5906 m; End Offset: 3.5999 m; Slope: 0.0223529
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569554
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569554
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 105.061; Additional Flow: 0; Velocity: 77.6716; Friction: 0.964842; Pressure Drop: 23.3613; Velocity Pressure: 102.721; Reynolds number: 630981
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 400ø; Diameter: 1.31234; Length: 7.38 m
PSet_Revit_Identity Data - Mark: 1513
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Size Lock: no; Loss Coefficient: 0.227424; Hydraulic Diameter: 1.31234; Section: 197; Insulation Thickness: 0; Lining Thickness: 0; Area: 9.27398 m2
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569556
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569556
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 90.0524; Additional Flow: 0; Velocity: 86.9559; Friction: 1.38757; Pressure Drop: 13.1707; Velocity Pressure: 128.746; Reynolds number: 618104
PSet_Revit_Identity Data - Mark: 1514
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 350ø; Diameter: 1.14829; Length: 2.89315 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.425 m; Top Elevation: 3.775 m; Size Lock: no; Loss Coefficient: 0.1023; Hydraulic Diameter: 1.14829; Section: 195; Insulation Thickness: 0; Lining Thickness: 0; Area: 3.18118 m2
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569558
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569558
PSet_Revit_Identity Data - Mark: 1515
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 300ø; Diameter: 0.984252; Length: 3.13964 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.45 m; Top Elevation: 3.75 m; Size Lock: no; Loss Coefficient: 0.136017; Hydraulic Diameter: 0.984252; Section: 226; Insulation Thickness: 0; Lining Thickness: 0; Area: 2.95905 m2
PSet_Revit_Mechanical - Airflow - Flow: 60.0349; Additional Flow: 0; Velocity: 78.9045; Friction: 1.3998; Pressure Drop: 14.4189; Velocity Pressure: 106.008; Reynolds number: 480747
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569560
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569560
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5 m; Top Elevation: 3.7 m; Size Lock: no; Loss Coefficient: 0.427788; Hydraulic Diameter: 0.656168; Section: 224; Insulation Thickness: 0; Lining Thickness: 0; Area: 3.90762 m2
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 6.21917 m
PSet_Revit_Mechanical - Airflow - Flow: 30.0175; Additional Flow: 0; Velocity: 88.7675; Friction: 2.8129; Pressure Drop: 57.3948; Velocity Pressure: 134.167; Reynolds number: 360561
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1516
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569562
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569562
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.60002 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5 m; Top Elevation: 3.70002 m; Size Lock: no; Loss Coefficient: 0.0710063; Hydraulic Diameter: 0.656168; Section: 428; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.563663 m2
PSet_Revit_Identity Data - Mark: 1517
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 2.38167; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.897097 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569563
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569563
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5 m; Top Elevation: 3.70002 m; Size Lock: no; Loss Coefficient: 0.0937354; Hydraulic Diameter: 0.656168; Section: 223; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.744091 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 3.14404; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 1.18426 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.60002 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1518
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569564
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569564
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1519
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 78.9045; Friction: 3.21519; Pressure Drop: 15.9906; Velocity Pressure: 106.008; Reynolds number: 240374
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 1.51591 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.525 m; Top Elevation: 3.675 m; Size Lock: no; Loss Coefficient: 0.150843; Hydraulic Diameter: 0.492126; Section: 431; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.714355 m2
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569565
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569565
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.988816 m
PSet_Revit_Identity Data - Mark: 1520
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.475 m; Top Elevation: 3.725 m; Size Lock: no; Loss Coefficient: 0.0655695; Hydraulic Diameter: 0.82021; Section: 236; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.776614 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 0.900837; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569566
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569566
PSet_Revit_Identity Data - Mark: 1521
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 1.15137; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 1.26382 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.475 m; Top Elevation: 3.725 m; Size Lock: no; Loss Coefficient: 0.083805; Hydraulic Diameter: 0.82021; Section: 194; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.992599 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569567
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569567
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 14.4927; Friction: 0.0553961; Pressure Drop: 0.17134; Velocity Pressure: 3.57628; Reynolds number: 103017
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.42497 m; Top Elevation: 3.77497 m; Size Lock: no; Loss Coefficient: 0.04791; Hydraulic Diameter: 1.14829; Section: 163; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.0366 m2
PSet_Revit_Dimensions - Size: 350ø; Diameter: 1.14829; Length: 0.942745 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.59997 m; Start Offset: 3.59997 m; End Offset: 3.59997 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1522
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569568
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569568
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.60002 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1523
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 1.96743; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5 m; Top Elevation: 3.70002 m; Size Lock: no; Loss Coefficient: 0.0586563; Hydraulic Diameter: 0.656168; Section: 406; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.465627 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.741068 m
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569572
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569572
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 2.2 m
PSet_Revit_Identity Data - Mark: 1526
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 30.0175; Additional Flow: 0; Velocity: 56.8112; Friction: 0.963851; Pressure Drop: 6.95693; Velocity Pressure: 54.9546; Reynolds number: 288448
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.475 m; Top Elevation: 3.725 m; Size Lock: no; Loss Coefficient: 0.126594; Hydraulic Diameter: 0.82021; Section: 315; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.72788 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569575
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569575
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5 m; Top Elevation: 3.7 m; Size Lock: no; Loss Coefficient: 0.31232; Hydraulic Diameter: 0.656168; Section: 313; Insulation Thickness: 0; Lining Thickness: 0; Area: 2.47926 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1527
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 3.94587 m
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 10.4757; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569577
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569577
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.50001 m; Top Elevation: 3.70002 m; Size Lock: no; Loss Coefficient: 0.0607655; Hydraulic Diameter: 0.656168; Section: 313; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.48237 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.767716 m
PSet_Revit_Identity Data - Mark: 1528
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 2.03818; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.60001 m; Start Offset: 3.60001 m; End Offset: 3.60002 m; Slope: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569578
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569578
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.475 m; Top Elevation: 3.725 m; Size Lock: no; Loss Coefficient: 0.0559967; Hydraulic Diameter: 0.82021; Section: 411; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.663233 m2
PSet_Revit_Identity Data - Mark: 1529
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.844454 m
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 0.769319; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569579
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569579
PSet_Revit_Mechanical - Airflow - Flow: 45.0262; Additional Flow: 0; Velocity: 43.478; Friction: 0.397676; Pressure Drop: 2.21801; Velocity Pressure: 32.1866; Reynolds number: 309052
PSet_Revit_Identity Data - Mark: 1530
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Dimensions - Size: 350ø; Diameter: 1.14829; Length: 1.7 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.425 m; Top Elevation: 3.775 m; Size Lock: no; Loss Coefficient: 0.068911; Hydraulic Diameter: 1.14829; Section: 275; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.86925 m2
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569581
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569581
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1531
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.45 m; Top Elevation: 3.75 m; Size Lock: no; Loss Coefficient: 0.356415; Hydraulic Diameter: 0.984252; Section: 273; Insulation Thickness: 0; Lining Thickness: 0; Area: 6.75157 m2
PSet_Revit_Dimensions - Size: 300ø; Diameter: 0.984252; Length: 7.16364 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 30.0175; Additional Flow: 0; Velocity: 39.4522; Friction: 0.401898; Pressure Drop: 9.44571; Velocity Pressure: 26.502; Reynolds number: 240374
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569583
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569583
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 19.7261; Friction: 0.115919; Pressure Drop: 0.288448; Velocity Pressure: 6.62551; Reynolds number: 120187
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.45 m; Top Elevation: 3.75 m; Size Lock: no; Loss Coefficient: 0.043536; Hydraulic Diameter: 0.984252; Section: 272; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.714825 m2
PSet_Revit_Dimensions - Size: 300ø; Diameter: 0.984252; Length: 0.758453 m
PSet_Revit_Identity Data - Mark: 1532
