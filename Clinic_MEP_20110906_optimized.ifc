Properties of the parts of a building model (IFC2X3), part 15 of 295

# IfcFlowFitting: 45 Degree (707)
Name | In | Length 2 | Length 1 | Mark | System Type | System Name | ASHRAE Table | Level | Host | Offset (m) | Size | OffsetHeight | OffsetWidth | Num8 | Num7 | Num6 | Num5 | Num4 | Num3 | Num2 | Num1 | PSet_Revit_Other, Delta 2 | PSet_Revit_Other, Delta 1 | WidthOffset | WidthDelta | Width2 = Lining Width 2 = Insulation Width 2 | Width1 = Lining Width 1 = Insulation Width 1 | MaxDelta = Length 01 = Computed Length | Lining Height 2 = Insulation Height 2 = Height2 | Lining Height 1 = Insulation Height 1 = Height1 | HeightOffset | HeightDelta | Half Width 2 | Half Width 1 | Half Height 2 | Half Height 1
M_Rectangular Transition - Angle:45 Degree:45 Degree:570160 | 2B4 | 0.198016 | 0.594049 | 8678 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:566846 | 1B15 | 0.198016 | 0.198016 | 634 | Return Air | Mechanical Return Air 1 |  | Level 1 | Level : Level 1 | 3.3 | 350x300-300x300 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.984252 | 1.14829 | 0.198016 | 0.984252 | 0.984252 | 10 | 0 | 0.492126 | 0.574147 | 0.492126 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568586 | 1E25 | 0.198016 | 0.594049 | 5446 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.50893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567036 | 1DC6 | 0.198016 | 1.1881 | 1071 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.64 | 350x450-350x150 | 0.738189 | 0.574147 | 6 | 36 | 6 | 6 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 1.1881 | 0.492126 | 1.47638 | 10 | 0.984252 | 0.574147 | 0.574147 | 0.246063 | 0.738189
M_Rectangular Transition - Angle:45 Degree:45 Degree:569447 | 2A11 | 0.594049 | 0.198016 | 6919 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.0705 | 350x250-200x250 | 0.410105 | 0.574147 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.656168 | 1.14829 | 0.594049 | 0.82021 | 0.82021 | 10 | 0 | 0.328084 | 0.574147 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:566777 | 1D20 | 0.198016 | 1.58413 | 388 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.93 | 450x600-450x200 | 0.984252 | 0.738189 | 8 | 64 | 8 | 8 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.47638 | 1.47638 | 1.58413 | 0.656168 | 1.9685 | 10 | 1.31234 | 0.738189 | 0.738189 | 0.328084 | 0.984252
M_Rectangular Transition - Angle:45 Degree:45 Degree:567817 | 1D30 | 0.198016 | 0.198016 | 3200 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.319 | 200x250-150x200 | 0.410105 | 0.328084 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.492126 | 0.656168 | 0.198016 | 0.656168 | 0.82021 | 10 | 0.164042 | 0.246063 | 0.328084 | 0.328084 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:569299 | 2CC1 | 0.396032 | 0.198016 | 6551 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.0705 | 250x250-150x200 | 0.410105 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.656168 | 0.82021 | 10 | 0.164042 | 0.246063 | 0.410105 | 0.328084 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:570738 | 1C04 | 0.198016 | 0.198016 | 592 | Supply Air | Mechanical Supply Air 1 |  | Level 2 | Level : Level 2 | -1.2105 | 200x250-150x250 | 0.410105 | 0.246063 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.656168 | 0.492126 | 0.198016 | 0.82021 | 0.82021 | 10 | 0 | 0.328084 | 0.246063 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:569131 | 2A01 | 0.198016 | 0.198016 | 6110 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71464 | 300x300-300x250 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.984252 | 0.984252 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.492126 | 0.492126 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570049 | 2B18 | 0.198016 | 0.594049 | 8499 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568195 | 1DC1 | 0.198016 | 0.198016 | 4475 | Supply Air | Mechanical Supply Air 1 |  | Level 2 | Level : Level 2 | -1.36053 | 150x300-150x250 | 0.492126 | 0.246063 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.492126 | 0.492126 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.246063 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567017 | 1D35 | 0.198016 | 0.594049 | 1040 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.35893 | 300x300-250x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568983 | 2A09 | 1.80446 | 0.198016 | 5650 | Return Air | Mechanical Return Air 2 |  | Roof - Main | Level : Roof - Main | -0.73 | 950x450-400x400 | 0.738189 | 0.656168 | 1 | 1 | 1 | 1 | 11 | 121 | 7.58007e-14 | 22 | 0 | 0.902231 | 9.09777 | 1.80446 | 1.31234 | 3.1168 | 1.80446 | 1.31234 | 1.47638 | 10 | 0.164042 | 0.656168 | 1.5584 | 0.656168 | 0.738189
M_Rectangular Transition - Angle:45 Degree:45 Degree:568068 | 1C08 | 0.198016 | 0.198016 | 4077 | Supply Air | Mechanical Supply Air 1 |  | Level 2 | Level : Level 2 | -1.21049 | 300x200-250x200 | 0.328084 | 0.492126 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.198016 | 0.656168 | 0.656168 | 10 | 0 | 0.410105 | 0.492126 | 0.328084 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:567749 | 1D35 | 0.396032 | 0.198016 | 3023 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.35952 | 250x200-150x250 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.246063 | 0.410105 | 0.410105 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:568517 | 1D30 | 0.594049 | 0.197214 | 5358 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.54 | 300x300-150x250 | 0.39649 | 0.246063 | 1 | 1 | 0.834 | 1.166 | 3 | 9 | 3 | 3 | 0.0136155 | 0 | 10 | 0.492126 | 0.984252 | 0.492126 | 0.594049 | 0.984252 | 0.82021 | 9.98638 | 0.164042 | 0.492126 | 0.246063 | 0.492126 | 0.410105
M_Round Transition - Angle:45 Degree:45 Degree:569078 | 2AC3 | 0.082021 | 0.082021 | 5920 | Supply Air | Mechanical Supply Air 2 | SD4-1 | Roof - Main | Level : Roof - Main | -1.08 | 400ø-350ø | 0.656168 | 0.656168 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0546807; OffsetHeightTemp: 0.0546807; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.574147; R0: 0.656168; Lining Radius 1: 0.574147; Lining Radius 0: 0.656168; Insulation Radius 1: 0.574147; Insulation Radius 0: 0.656168; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular Transition - Angle:45 Degree:45 Degree:570623 | 1BC2 | 0.495041 | 0.791006 | 274 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.69955 | 475x450-350x250 | 0.706857 | 0.779199 | 4 | 16 | 3.618 | 4.382 | 2.5 | 6.25 | 2.5 | 2.5 | 0.031332 | 0 | 10 | 0.410105 | 1.14829 | 1.5584 | 0.791006 | 0.82021 | 1.47638 | 9.96867 | 0.656168 | 0.574147 | 0.779199 | 0.410105 | 0.738189
M_Rectangular Transition - Angle:45 Degree:45 Degree:568216 | 1D22 | 0.396032 | 0.198016 | 4552 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.3605 | 250x300-150x300 | 0.492126 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.984252 | 0.984252 | 10 | 0 | 0.246063 | 0.410105 | 0.492126 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569058 | 2A12 | 0.594049 | 0.198016 | 5808 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-150x350 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.574147 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569109 | 2A04 | 0.594049 | 0.396032 | 6068 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.66893 | 300x300-150x400 | 0.492126 | 0.492126 | 2 | 4 | 2 | 2 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.31234 | 0.984252 | 10 | 0.328084 | 0.246063 | 0.492126 | 0.656168 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567808 | 1D33 | 0.396032 | 0.198016 | 3165 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.31903 | 250x200-150x250 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.246063 | 0.410105 | 0.410105 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:570668 | 1A16 | 3.76231 | 0.594049 | 423 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.454 | 1200x300-250x150 | 0.492126 | 1.9685 | 3 | 9 | 3 | 3 | 19 | 361 | 19 | 19 | 0 | 0 | 10 | 3.1168 | 0.82021 | 3.93701 | 3.76231 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 1.9685 | 0.246063 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568674 | 1EC1 | 0.246063 | 0.246063 | 5508 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569150 | 2C01 | 0.594049 | 0.198016 | 6145 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.66893 | 300x300-150x350 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.574147 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567005 | 1B13 | 0.198016 | 0.594049 | 1018 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.3 | 450x300-450x150 | 0.492126 | 0.738189 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.47638 | 1.47638 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.738189 | 0.738189 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570200 | 2D05 | 2.77223 | 0.594049 | 8745 | Return Air | Mechanical Return Air 2 |  | Roof - Main | Level : Roof - Main | -1.06378 | 2000x850-1300x1000 | 1.64042 | 2.13255 | 3 | 9 | 3 | 3 | 14 | 196 | 14 | 14 | 0 | 0 | 10 | 2.29659 | 6.56168 | 4.26509 | 2.77223 | 2.78871 | 3.28084 | 10 | 0.492126 | 3.28084 | 2.13255 | 1.39436 | 1.64042
M_Rectangular Transition - Angle:45 Degree:45 Degree:568985 | 2A08 | 0.198016 | 0.198016 | 5665 | Return Air | Mechanical Return Air 2 |  | Roof - Main | Level : Roof - Main | -0.73 | 400x400-400x350 | 0.656168 | 0.656168 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.31234 | 1.31234 | 0.198016 | 1.14829 | 1.31234 | 10 | 0.164042 | 0.656168 | 0.656168 | 0.574147 | 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:569115 | 2A03 | 0.198016 | 0.198016 | 6080 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.73 | 400x200-400x150 | 0.328084 | 0.656168 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.31234 | 1.31234 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.656168 | 0.656168 | 0.246063 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:570636 | 1D02 | 2.37619 | 0.198016 | 323 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.545 | 800x300-200x250 | 0.492126 | 1.31234 | 1 | 1 | 1 | 1 | 12 | 144 | 12 | 12 | 0 | 0 | 10 | 1.9685 | 0.656168 | 2.62467 | 2.37619 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.328084 | 1.31234 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568987 | 2A07 | 0.198016 | 0.594049 | 5681 | Return Air | Mechanical Return Air 2 |  | Roof - Main | Level : Roof - Main | -0.73 | 400x350-400x200 | 0.574147 | 0.656168 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.31234 | 1.31234 | 0.594049 | 0.656168 | 1.14829 | 10 | 0.492126 | 0.656168 | 0.656168 | 0.328084 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:568043 | 1C10 | 0.396032 | 0.198016 | 4037 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -0.860475 | 250x200-150x250 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.246063 | 0.410105 | 0.410105 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:566770 | 1DC1 | 0.198016 | 0.198016 | 372 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.78 | 650x300-650x250 | 0.492126 | 1.06627 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 2.13255 | 2.13255 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 1.06627 | 1.06627 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568495 | 1A03 | 0.594049 | 0.198016 | 5325 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -1.425 | 300x300-150x250 | 0.410105 | 0.246063 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.984252 | 0.492126 | 0.594049 | 0.984252 | 0.82021 | 10 | 0.164042 | 0.492126 | 0.246063 | 0.492126 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:567923 | 1A07 | 0.396032 | 0.198016 | 3580 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -0.860475 | 250x200-150x250 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.246063 | 0.410105 | 0.410105 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:569826 | 2D07 | 0.198016 | 0.396032 | 8000 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.27048 | 200x300-250x200 | 0.328084 | 0.410105 | 2 | 4 | 2 | 2 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.656168 | 0.82021 | 0.396032 | 0.984252 | 0.656168 | 10 | 0.328084 | 0.328084 | 0.410105 | 0.492126 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:569103 | 2A02 | 0.198016 | 0.594049 | 6040 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.73 | 400x350-400x200 | 0.574147 | 0.656168 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.31234 | 1.31234 | 0.594049 | 0.656168 | 1.14829 | 10 | 0.492126 | 0.656168 | 0.656168 | 0.328084 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:1119817 | 1E16 | 0.198016 | 0.198016 | 1025 | Supply Air | Mechanical Supply Air 1 |  | Level 1 | Level : Level 1 | 3.40953 | 350x250-300x200 | 0.328084 | 0.492126 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.198016 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.574147 | 0.492126 | 0.410105 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:569195 | 2C16 | 0.396032 | 0.396032 | 6224 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Level 2 | Level : Level 2 | 3.16377 | 300x300-400x200 | 0.492126 | 0.492126 | 2 | 4 | 2 | 2 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 1.31234 | 0.984252 | 0.396032 | 0.656168 | 0.984252 | 10 | 0.328084 | 0.656168 | 0.492126 | 0.328084 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569443 | 2A09 | 0.495041 | 0.396032 | 6884 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.17045 | 275x250-150x350 | 0.409941 | 0.451115 | 2 | 4 | 1.998 | 2.002 | 2.5 | 6.25 | 2.5 | 2.5 | 0.000164042 | 0 | 10 | 0.410105 | 0.492126 | 0.902231 | 0.495041 | 1.14829 | 0.82021 | 9.99984 | 0.328084 | 0.246063 | 0.451115 | 0.574147 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:570606 | 1B01 | 2.17818 | 0.594049 | 240 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.454 | 800x300-250x150 | 0.492126 | 1.31234 | 3 | 9 | 3 | 3 | 11 | 121 | 11 | 11 | 0 | 0 | 10 | 1.80446 | 0.82021 | 2.62467 | 2.17818 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 1.31234 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567985 | 1A16 | 0.198016 | 0.198016 | 3804 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -0.860475 | 350x300-300x300 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.984252 | 1.14829 | 0.198016 | 0.984252 | 0.984252 | 10 | 0 | 0.492126 | 0.574147 | 0.492126 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569139 | 2A11 | 0.198016 | 0.989849 | 6129 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.42329 | 300x550-300x300 | 0.50853 | 0.492126 | 5 | 25 | 4.8 | 5.2 | 1 | 1 | 1 | 1 | 0.0164042 | 0 | 10 | 0 | 0.984252 | 0.984252 | 0.989849 | 1.80446 | 0.984252 | 10.0164 | 0.82021 | 0.492126 | 0.492126 | 0.902231 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569817 | 2D10 | 0.495041 | 0.198016 | 7956 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.27047 | 275x250-150x300 | 0.409941 | 0.451115 | 1 | 1 | 0.998 | 1.002 | 2.5 | 6.25 | 2.5 | 2.5 | 0.000164042 | 0 | 10 | 0.410105 | 0.492126 | 0.902231 | 0.495041 | 0.984252 | 0.82021 | 9.99984 | 0.164042 | 0.246063 | 0.451115 | 0.492126 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:566818 | 1A16 | 0.198016 | 0.198016 | 567 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -1.325 | 200x200-200x150 | 0.328084 | 0.328084 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.656168 | 0.656168 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.328084 | 0.328084 | 0.246063 | 0.328084
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567789 | 1D34 | 0.246063 | 0.246063 | 3131 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:566844 | 1B13 | 2.13255 | 0.198016 | 632 | Return Air | Mechanical Return Air 1 |  | Level 1 | Level : Level 1 | 3.3 | 1000x300-350x300 | 0.492126 | 2.70669 | 1 | 1 | 1 | 1 | 13 | 169 | 1.08287e-14 | 26 | 0 | 1.06627 | 11.0663 | 2.13255 | 1.14829 | 3.28084 | 2.13255 | 0.984252 | 0.984252 | 10 | 0 | 0.574147 | 1.64042 | 0.492126 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569124 | 2A02 | 0.594049 | 0.198016 | 6096 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.66893 | 300x300-150x350 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.574147 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570075 | 2B8 | 0.492126 | 0.198016 | 8526 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.68 | 500x350-350x350 | 0.574147 | 0.574147 | 1 | 1 | 1 | 1 | 3 | 9 | -1.08287e-14 | 6 | 0 | 0.246063 | 9.75394 | 0.492126 | 1.14829 | 1.64042 | 0.492126 | 1.14829 | 1.14829 | 10 | 0 | 0.574147 | 0.82021 | 0.574147 | 0.574147
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568383 | 1EC1 | 0.246063 | 0.246063 | 5126 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570586 | 1A16 | 0.198016 | 0.198016 | 138 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.70953 | 350x300-300x250 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.984252 | 1.14829 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.492126 | 0.574147 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569045 | 2A06 | 0.396032 | 0.594049 | 5770 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-400x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 1.31234 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.656168 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567384 | 1E04 | 0.396032 | 0.198016 | 1831 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.3 | 200x250-100x250 | 0.410105 | 0.328084 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.328084 | 0.656168 | 0.396032 | 0.82021 | 0.82021 | 10 | 0 | 0.164042 | 0.328084 | 0.410105 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567873 | 1E30 | 0.246063 | 0.246063 | 3401 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:566810 | 1A16 | 0.396032 | 0.198016 | 539 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -1.325 | 500x200-400x200 | 0.328084 | 0.82021 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 1.31234 | 1.64042 | 0.396032 | 0.656168 | 0.656168 | 10 | 0 | 0.656168 | 0.82021 | 0.328084 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:567709 | 1BC4 | 0.198016 | 0.198016 | 2928 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.41995 | 350x300-350x250 | 0.49229 | 0.574147 | 1 | 1 | 0.998 | 1.002 | 1 | 1 | 1 | 1 | 0.000164042 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.198016 | 0.82021 | 0.984252 | 10.0002 | 0.164042 | 0.574147 | 0.574147 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570121 | 2B17 | 0.198016 | 0.198016 | 8619 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.68 | 350x200-350x150 | 0.328084 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.574147 | 0.574147 | 0.246063 | 0.328084
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567880 | 1E23 | 0 | 0 | 3408 | Supply Air | Mechanical Supply Air 1 | SD4-2 | Level 1 | Level : Level 1 | 3.7241 | 150x250-150ø | 0.410105 | 0.246063 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 0; Length 8: 0; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.410105; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.246063; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0; W0: 0.492126; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.492126; Lining Radius: 0.246063; Lining H0: 0.82021; Length01: 0.396032; Insulation W0: 0.492126; Insulation Radius: 0.246063; Insulation H0: 0.82021; H0: 0.82021; OffsetWidthTemp: -0.0208333; OffsetHeightTemp: 0.0347222; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567571 | 1B01 | -2.13163e-14 | 2.13163e-14 | 2399 | Supply Air | Mechanical Supply Air 1 | SD4-2 | Level 1 | Level : Level 1 | 3.79952 | 150x250-150ø | 0.410105 | 0.246063 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2.59888e-13; Length 8: 0; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.410105; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: -2.59888e-13; Length 3: 0; Half W0: 0.246063; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0; W0: 0.492126; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.492126; Lining Radius: 0.246063; Lining H0: 0.82021; Length01: 0.396032; Insulation W0: 0.492126; Insulation Radius: 0.246063; Insulation H0: 0.82021; H0: 0.82021; OffsetWidthTemp: -0.0208333; OffsetHeightTemp: 0.0347222; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568155 | 1D16 | 0.396032 | 0.198016 | 4349 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.2605 | 300x250-200x250 | 0.410105 | 0.492126 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.656168 | 0.984252 | 0.396032 | 0.82021 | 0.82021 | 10 | 0 | 0.328084 | 0.492126 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:567026 | 1D34 | 0.198016 | 0.594049 | 1056 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.35893 | 300x300-250x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569091 | 2AC2 | 0.396032 | 0.198016 | 5962 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.73 | 750x400-650x400 | 0.656168 | 1.23031 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 2.13255 | 2.46063 | 0.396032 | 1.31234 | 1.31234 | 10 | 0 | 1.06627 | 1.23031 | 0.656168 | 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:570015 | 2D08 | 0.198016 | 0.594049 | 8397 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567658 | 1D23 | 0.297024 | 0.198016 | 2717 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.20953 | 275x250-200x300 | 0.410105 | 0.451115 | 1 | 1 | 1 | 1 | 1.5 | 2.25 | 1.5 | 1.5 | 0 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.297024 | 0.984252 | 0.82021 | 10 | 0.164042 | 0.328084 | 0.451115 | 0.492126 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:570081 | 2B23 | 0.198016 | 0.396032 | 8565 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.68 | 350x300-350x200 | 0.492126 | 0.574147 | 2 | 4 | 2 | 2 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.396032 | 0.656168 | 0.984252 | 10 | 0.328084 | 0.574147 | 0.574147 | 0.328084 | 0.492126
M_Round Transition - Angle:45 Degree:45 Degree:567790 | 1D34 | 0.082021 | 0.082021 | 3132 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 1 | Level : Level 1 | 3.3096 | 200ø-150ø | 0.328084 | 0.328084 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0273403; OffsetHeightTemp: 0.0273403; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.246063; R0: 0.328084; Lining Radius 1: 0.246063; Lining Radius 0: 0.328084; Insulation Radius 1: 0.246063; Insulation Radius 0: 0.328084; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular Transition - Angle:45 Degree:45 Degree:570110 | 2B19 | 0.198016 | 0.594049 | 8605 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567038 | 1DC6 | 0.198016 | 0.594049 | 1073 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.35893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567674 | 1E14 | 0.198016 | 0.198016 | 2771 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.29998 | 200x200-150x200 | 0.328084 | 0.328084 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.492126 | 0.656168 | 0.198016 | 0.656168 | 0.656168 | 10 | 0 | 0.246063 | 0.328084 | 0.328084 | 0.328084
M_Round Transition - Angle:45 Degree:45 Degree:1121612 | 1B04 | 0.082021 | 0.082021 | 1194 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 1 | Level : Level 1 | 3.79 | 300ø-250ø | 0.410105 | 0.410105 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 4.26326e-14; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0341754; OffsetHeightTemp: 0.0341754; WidthOffsetfromBase: 10; Offest Delta: 1.77636e-15; DiameterDelta: 0.082021; R1: 0.492126; R0: 0.410105; Lining Radius 1: 0.492126; Lining Radius 0: 0.410105; Insulation Radius 1: 0.492126; Insulation Radius 0: 0.410105; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular Transition - Angle:45 Degree:45 Degree:567704 | 1DC7 | 0.198016 | 0.594049 | 2909 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.715 | 350x300-350x150 | 0.492126 | 0.574147 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.574147 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:566796 | 1D05 | 0.198016 | 0.198016 | 480 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -1.27 | 200x200-200x150 | 0.328084 | 0.328084 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.656168 | 0.656168 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.328084 | 0.328084 | 0.246063 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:567905 | 1A08 | 0.328084 | 0.198016 | 3462 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.93 | 750x350-650x350 | 0.574147 | 1.23031 | 1 | 1 | 1 | 1 | 2 | 4 | 1.08287e-13 | 4 | 0 | 0.164042 | 10.164 | 0.328084 | 2.46063 | 2.13255 | 0.328084 | 1.14829 | 1.14829 | 10 | 0 | 1.23031 | 1.06627 | 0.574147 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:570672 | 1A01 | 3.76231 | 0.594049 | 439 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.454 | 1200x300-250x150 | 0.492126 | 1.9685 | 3 | 9 | 3 | 3 | 19 | 361 | 19 | 19 | 0 | 0 | 10 | 3.1168 | 0.82021 | 3.93701 | 3.76231 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 1.9685 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568575 | 1E23 | 0.594049 | 0.396032 | 5432 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.53393 | 300x300-150x200 | 0.492126 | 0.492126 | 2 | 4 | 2 | 2 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 0.656168 | 0.984252 | 10 | 0.328084 | 0.246063 | 0.492126 | 0.328084 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567813 | 1D31 | 0.198016 | 0.198016 | 3170 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.31903 | 200x250-250x200 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.656168 | 0.82021 | 0.198016 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.328084 | 0.410105 | 0.410105 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:569378 | 2C19 | 0.297024 | 0.198016 | 6762 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.43 | 275x250-200x250 | 0.410105 | 0.451115 | 1 | 1 | 1 | 1 | 1.5 | 2.25 | 1.5 | 1.5 | 0 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.297024 | 0.82021 | 0.82021 | 10 | 0 | 0.328084 | 0.451115 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:570033 | 2D02 | 0.594049 | 0.198016 | 8462 | Return Air | Mechanical Return Air 2 |  | Roof - Main | Level : Roof - Main | -0.68 | 950x400-800x400 | 0.656168 | 1.5584 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 2.62467 | 3.1168 | 0.594049 | 1.31234 | 1.31234 | 10 | 0 | 1.31234 | 1.5584 | 0.656168 | 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:570149 | 2B3 | 0.198016 | 0.198016 | 8670 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.68 | 400x200-400x150 | 0.328084 | 0.656168 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.31234 | 1.31234 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.656168 | 0.656168 | 0.246063 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:569196 | 2C16 | 0.198016 | 0.396032 | 6226 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.27052 | 350x300-400x200 | 0.328248 | 0.656168 | 2 | 4 | 1.998 | 2.002 | 1 | 1 | 1 | 1 | 0.000164042 | 0 | 10 | 0.164042 | 1.14829 | 1.31234 | 0.396032 | 0.984252 | 0.656168 | 10.0002 | 0.328084 | 0.574147 | 0.656168 | 0.492126 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:567751 | 1DC8 | 0.396032 | 0.198016 | 3044 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.30952 | 250x200-150x200 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.656168 | 0.656168 | 10 | 0 | 0.246063 | 0.410105 | 0.328084 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:570069 | Level 2 | 0.396032 | 0.594049 | 8520 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-200x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.656168 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.328084 | 0.492126 | 0.246063 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568592 | 1D16 | 0.246063 | 0.246063 | 5454 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Round Transition - Angle:45 Degree:45 Degree:569247 | 2CC1 | 0.164042 | 0.164042 | 6388 | Supply Air | Mechanical Supply Air 2 | SD4-1 | Roof - Main | Level : Roof - Main | -1.08 | 400ø-300ø | 0.656168 | 0.656168 | PSet_Revit_Other - Num 1: 1.9685; Num 5: 4.75239; Num 4: 1; Num 3: 3.93701; Num 2: 1.9685; Length 3: 1.42109e-14; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0546807; OffsetHeightTemp: 0.0546807; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.164042; R1: 0.492126; R0: 0.656168; Lining Radius 1: 0.492126; Lining Radius 0: 0.656168; Insulation Radius 1: 0.492126; Insulation Radius 0: 0.656168; HeightOffsetfromBase: 10; ComputedLength: 0.396032
M_Rectangular Transition - Angle:45 Degree:45 Degree:570205 | 2D05 | 0.396032 | 0.198016 | 8761 | Return Air | Mechanical Return Air 2 |  | Roof - Main | Level : Roof - Main | -0.78 | 700x500-600x500 | 0.82021 | 0.984252 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 2.29659 | 1.9685 | 0.396032 | 1.64042 | 1.64042 | 10 | 0 | 1.14829 | 0.984252 | 0.82021 | 0.82021
M_Rectangular Transition - Angle:45 Degree:45 Degree:566857 | 1B08 | 0.198016 | 0.198016 | 712 | Return Air | Mechanical Return Air 1 |  | Level 1 | Level : Level 1 | 3.3 | 350x200-350x150 | 0.328084 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.574147 | 0.574147 | 0.246063 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:569283 | 2C02 | 0.495041 | 0.396032 | 6464 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.1705 | 275x250-150x350 | 0.410105 | 0.451115 | 2 | 4 | 2 | 2 | 2.5 | 6.25 | 2.5 | 2.5 | 0 | 0 | 10 | 0.410105 | 0.492126 | 0.902231 | 0.495041 | 1.14829 | 0.82021 | 10 | 0.328084 | 0.246063 | 0.451115 | 0.574147 | 0.410105
M_Round Transition - Angle:45 Degree:45 Degree:1121875 | 2D18 | 0.164042 | 0.164042 | 1217 | Supply Air | Mechanical Supply Air 2 | SD4-1 | Level 2 | Level : Level 2 | 3.4 | 350ø-250ø | 0.410105 | 0.410105 | PSet_Revit_Other - Num 1: 1.9685; Num 5: 4.75239; Num 4: 1; Num 3: 3.93701; Num 2: 1.9685; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0341754; OffsetHeightTemp: 0.0341754; WidthOffsetfromBase: 10; Offest Delta: -2.13163e-14; DiameterDelta: 0.164042; R1: 0.574147; R0: 0.410105; Lining Radius 1: 0.574147; Lining Radius 0: 0.410105; Insulation Radius 1: 0.574147; Insulation Radius 0: 0.410105; HeightOffsetfromBase: 10; ComputedLength: 0.396032
M_Rectangular Transition - Angle:45 Degree:45 Degree:570676 | 1AC5 | 3.76231 | 0.594049 | 456 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.454 | 1200x300-250x150 | 0.492126 | 1.9685 | 3 | 9 | 3 | 3 | 19 | 361 | 19 | 19 | 0 | 0 | 10 | 3.1168 | 0.82021 | 3.93701 | 3.76231 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 1.9685 | 0.246063 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568047 | 1C10 | 0.246063 | 0.246063 | 4041 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569099 | 2A14 | 0.198016 | 0.198016 | 6021 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.73 | 400x400-400x350 | 0.656168 | 0.656168 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.31234 | 1.31234 | 0.198016 | 1.14829 | 1.31234 | 10 | 0.164042 | 0.656168 | 0.656168 | 0.574147 | 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:570613 | 1AC1 | 2.17818 | 0.594049 | 260 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.454 | 800x300-250x150 | 0.492126 | 1.31234 | 3 | 9 | 3 | 3 | 11 | 121 | 11 | 11 | 0 | 0 | 10 | 1.80446 | 0.82021 | 2.62467 | 2.17818 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 1.31234 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570123 | 2B17 | 0.594049 | 0.198016 | 8621 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-150x350 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.574147 | 0.492126
M_Round Transition - Angle:45 Degree:45 Degree:567732 | 1DC7 | 0.082021 | 0.082021 | 2981 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 1 | Level : Level 1 | 3.3 | 200ø-150ø | 0.328084 | 0.328084 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0273403; OffsetHeightTemp: 0.0273403; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.246063; R0: 0.328084; Lining Radius 1: 0.246063; Lining Radius 0: 0.328084; Insulation Radius 1: 0.246063; Insulation Radius 0: 0.328084; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular Transition - Angle:45 Degree:45 Degree:570165 | 2B7 | 0.198016 | 0.594049 | 8682 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-350x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.14829 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.574147 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568153 | 1D16 | 0.198016 | 0.198016 | 4343 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.26048 | 350x300-300x250 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.984252 | 1.14829 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.492126 | 0.574147 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570146 | 2B11 | 0.198016 | 0.198016 | 8654 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.68 | 400x300-400x250 | 0.492126 | 0.656168 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.31234 | 1.31234 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.656168 | 0.656168 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567720 | 1BC4 | 0.198016 | 0.198016 | 2948 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.69952 | 400x300-350x300 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.31234 | 1.14829 | 0.198016 | 0.984252 | 0.984252 | 10 | 0 | 0.656168 | 0.574147 | 0.492126 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:1125616 | 1B02 | 0.198016 | 0.387478 | 1295 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.79952 | 350x300-400x200 | 0.429708 | 0.574147 | 2 | 4 | 1.239 | 2.761 | 1 | 1 | 1 | 1 | 0.062418 | 0 | 10 | 0.164042 | 1.31234 | 1.14829 | 0.387478 | 0.656168 | 0.984252 | 9.93758 | 0.328084 | 0.656168 | 0.574147 | 0.328084 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569004 | 2C14 | 0.594049 | 0.594049 | 5717 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-450x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 1.47638 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.738189 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568578 | 1E16 | 0.198016 | 0.198016 | 5437 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.755 | 350x200-350x150 | 0.328084 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.574147 | 0.574147 | 0.246063 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:569710 | 2DC2 | 0.297024 | 0.198016 | 7691 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07045 | 275x250-200x250 | 0.409941 | 0.451115 | 1 | 1 | 1 | 1 | 1.5 | 2.25 | 1.5 | 1.5 | 0.000164042 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.297024 | 0.82021 | 0.82021 | 9.99984 | 0 | 0.328084 | 0.451115 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:570662 | 1A16 | 3.76231 | 0.594049 | 404 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.454 | 1200x300-250x150 | 0.492126 | 1.9685 | 3 | 9 | 3 | 3 | 19 | 361 | 19 | 19 | 0 | 0 | 10 | 3.1168 | 0.82021 | 3.93701 | 3.76231 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 1.9685 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567624 | 1D25 | 0.396032 | 0.198016 | 2617 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.2905 | 350x300-250x250 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.82021 | 1.14829 | 0.396032 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.410105 | 0.574147 | 0.410105 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567879 | 1E23 | 0.246063 | 0.246063 | 3406 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567389 | 1EC2 | 0.495041 | 0.198016 | 1867 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.79952 | 425x350-300x300 | 0.574147 | 0.697178 | 1 | 1 | 1 | 1 | 2.5 | 6.25 | 2.5 | 2.5 | 0 | 0 | 10 | 0.410105 | 0.984252 | 1.39436 | 0.495041 | 0.984252 | 1.14829 | 10 | 0.164042 | 0.492126 | 0.697178 | 0.492126 | 0.574147
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568683 | 1E16 | 0.246063 | 0.246063 | 5513 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:566808 | 1A16 | 0.198016 | 0.198016 | 516 | Return Air | Mechanical Return Air 1 |  | Level 2 | Level : Level 2 | -1.325 | 550x250-500x200 | 0.410105 | 0.902231 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 1.64042 | 1.80446 | 0.198016 | 0.656168 | 0.82021 | 10 | 0.164042 | 0.82021 | 0.902231 | 0.328084 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:567837 | 1E16 | 0.396032 | 0.198016 | 3283 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.40953 | 300x200-200x200 | 0.328084 | 0.492126 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.656168 | 0.984252 | 0.396032 | 0.656168 | 0.656168 | 10 | 0 | 0.328084 | 0.492126 | 0.328084 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:569287 | 2C24 | 0.594049 | 0.198016 | 6477 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.0705 | 300x250-150x250 | 0.410105 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 0.82021 | 0.82021 | 10 | 0 | 0.246063 | 0.492126 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:567646 | 1D24 | 0.297024 | 0.198016 | 2677 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.26998 | 275x250-200x250 | 0.410105 | 0.451115 | 1 | 1 | 1 | 1 | 1.5 | 2.25 | 1.5 | 1.5 | 0 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.297024 | 0.82021 | 0.82021 | 10 | 0 | 0.328084 | 0.451115 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:567676 | 1E33 | 0.495041 | 0.198016 | 2787 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.3 | 275x250-150x250 | 0.410105 | 0.451115 | 1 | 1 | 1 | 1 | 2.5 | 6.25 | 2.5 | 2.5 | 0 | 0 | 10 | 0.410105 | 0.492126 | 0.902231 | 0.495041 | 0.82021 | 0.82021 | 10 | 0 | 0.246063 | 0.451115 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:567119 | 1E24 | 0.792065 | 0.396032 | 1221 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.79 | 500x200-300x300 | 0.492126 | 0.492126 | 2 | 4 | 2 | 2 | 4 | 16 | 4 | 4 | 0 | 0 | 10 | 0.656168 | 1.64042 | 0.984252 | 0.792065 | 0.656168 | 0.984252 | 10 | 0.328084 | 0.82021 | 0.492126 | 0.328084 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570171 | 2D01 | 0.594049 | 0.198016 | 8687 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-150x250 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.410105 | 0.492126
M_Round Transition - Angle:45 Degree:45 Degree:568048 | 1C10 | 0.082021 | 0.082021 | 4042 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 1 | Level : Level 1 | 3.70951 | 200ø-150ø | 0.328084 | 0.328084 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0273403; OffsetHeightTemp: 0.0273403; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.246063; R0: 0.328084; Lining Radius 1: 0.246063; Lining Radius 0: 0.328084; Insulation Radius 1: 0.246063; Insulation Radius 0: 0.328084; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular Transition - Angle:45 Degree:45 Degree:566912 | 1A07 | 0.164042 | 0.396032 | 821 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.93 | 650x350-600x250 | 0.574147 | 1.14829 | 2 | 4 | 2 | 2 | 1 | 1 | -1.19115e-13 | 2 | 0 | 0.082021 | 10.082 | 0.164042 | 1.9685 | 2.13255 | 0.396032 | 0.82021 | 1.14829 | 10 | 0.328084 | 0.984252 | 1.06627 | 0.410105 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:570063 | 2BC2 | 0.396032 | 0.198016 | 8515 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 4 | 400x250-300x300 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 1.31234 | 0.984252 | 0.396032 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.656168 | 0.492126 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568580 | 1E18 | 0.594049 | 0.198016 | 5439 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.53393 | 300x300-150x350 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.574147 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:570031 | 2D04-A | 0.198016 | 0.198016 | 8433 | Return Air | Mechanical Return Air 2 |  | Roof - Main | Level : Roof - Main | -0.68 | 1000x400-950x400 | 0.656168 | 1.64042 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 3.1168 | 3.28084 | 0.198016 | 1.31234 | 1.31234 | 10 | 0 | 1.5584 | 1.64042 | 0.656168 | 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:568981 | 2C02 | 0.164042 | 0.198016 | 5621 | Return Air | Mechanical Return Air 2 |  | Roof - Main | Level : Roof - Main | -0.73 | 1000x500-950x450 | 0.82021 | 1.5584 | 1 | 1 | 1 | 1 | 1 | 1 | -1.19115e-13 | 2 | 0 | 0.082021 | 9.91798 | 0.164042 | 3.1168 | 3.28084 | 0.198016 | 1.47638 | 1.64042 | 10 | 0.164042 | 1.5584 | 1.64042 | 0.738189 | 0.82021
M_Rectangular Transition - Angle:45 Degree:45 Degree:570117 | 2B8 | 0.594049 | 0.198016 | 8613 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-150x350 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.492126 | 0.984252 | 0.594049 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.246063 | 0.492126 | 0.574147 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569105 | 2A03 | 0.198016 | 0.198016 | 6057 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.73 | 400x200-400x150 | 0.328084 | 0.656168 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.31234 | 1.31234 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.656168 | 0.656168 | 0.246063 | 0.328084
M_Rectangular Transition - Angle:45 Degree:45 Degree:568133 | 1C18 | 0.297024 | 0.198016 | 4290 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -1.26048 | 275x250-200x250 | 0.410105 | 0.451115 | 1 | 1 | 1 | 1 | 1.5 | 2.25 | 1.5 | 1.5 | 0 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.297024 | 0.82021 | 0.82021 | 10 | 0 | 0.328084 | 0.451115 | 0.410105 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:570646 | 1DC2 | 0.198016 | 0.198016 | 339 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 1 | Level : Level 1 | 3.70953 | 350x300-300x250 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.984252 | 1.14829 | 0.198016 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.492126 | 0.574147 | 0.410105 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:1138536 | 1B08 | 0.198016 | 0.198016 | 1461 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.3 | 200x200-200x150 | 0.246063 | 0.328084 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.656168 | 0.656168 | 0.198016 | 0.656168 | 0.492126 | 10 | 0.164042 | 0.328084 | 0.328084 | 0.328084 | 0.246063
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567782 | 1D36 | 0.246063 | 0.246063 | 3125 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:568121 | 1C18 | 0.396032 | 0.594049 | 4269 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.35893 | 300x300-400x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 1.31234 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.656168 | 0.492126 | 0.246063 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569135 | 2A14 | 0.198016 | 0.395452 | 6121 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.60447 | 300x400-300x300 | 0.50853 | 0.492126 | 2 | 4 | 1.8 | 2.2 | 1 | 1 | 1 | 1 | 0.0164042 | 0 | 10 | 0 | 0.984252 | 0.984252 | 0.395452 | 1.31234 | 0.984252 | 10.0164 | 0.328084 | 0.492126 | 0.492126 | 0.656168 | 0.492126
M_Round Transition - Angle:45 Degree:45 Degree:568055 | 1CC2 | 0.164042 | 0.164042 | 4049 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 2 | Level : Level 2 | -1.27 | 300ø-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 1: 1.9685; Num 5: 4.75239; Num 4: 1; Num 3: 3.93701; Num 2: 1.9685; Length 3: 1.42109e-14; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0410105; OffsetHeightTemp: 0.0410105; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.164042; R1: 0.328084; R0: 0.492126; Lining Radius 1: 0.328084; Lining Radius 0: 0.492126; Insulation Radius 1: 0.328084; Insulation Radius 0: 0.492126; HeightOffsetfromBase: 10; ComputedLength: 0.396032
M_Rectangular Transition - Angle:45 Degree:45 Degree:570020 | 2D07 | 0.198016 | 0.594049 | 8401 | Return Air | Mechanical Return Air 2 | ER4-1 | Level 2 | Level : Level 2 | 3.71893 | 300x300-250x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.594049 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.410105 | 0.492126 | 0.246063 | 0.492126
