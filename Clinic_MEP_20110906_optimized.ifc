Properties of the parts of a building model (IFC2X3), part 31 of 295

# IfcFlowFitting: Standard (800)
Name | In | Level | Host | Offset (m) | Lining Width = Insulation Width | Lining Height = Insulation Height | Size | System Type | System Name | Mark | Takeoff Fixed Length | Takeoff Length Projection | Takeoff Length
M_Oval Elbow - Gored:Standard:Standard:567891 | 1C02 | Level 2 | Level : Level 2 | -0.87 | 2.95276 | 1.64042 | 900/500-900/500 | Supply Air | Mechanical Supply Air 1 | 3419 | PSet_Revit_Dimensions - Angle: 90 deg; Duct Width: 2.95276; Duct Height: 1.64042; Max Segmentation Angle: 22.5 deg; Gores: 5; Center Radius: 4.42913; PSet_Revit_Mechanical - ASHRAE Table: CF3-1; PSet_Revit_Other - Length 3: 4.59318; Length 2: 4.42913; Length 1: 4.42913; End Length: 0.164042; Length 5: 0.164042; Length 4: 1.00447e-17
M_Rectangular Tee:Standard:Standard:566897 | 1DC7 | Level 1 | Level : Level 1 | 3.64 | 4.42913 | 1.47638 | 1350x450-1350x450-250x450 | Return Air | Mechanical Return Air 1 | 787 | PSet_Revit_Dimensions - Width: 4.42913; Length1: 0.492126; Height: 1.47638; Width3: 0.82021; Shoulder: 0.082021; Lining Width3: 0.82021; Length3a: 2.21457; Length3: 2.29659; Length1a: 0.410105; Insulation Width3: 0.82021
M_Round Takeoff:Standard:Standard:569624 | 2BC4 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 7457 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Oval Elbow - Gored:Standard:Standard:569522 | 2DC1 | Roof - Main | Level : Roof - Main | -1.08 | 1.9685 | 1.31234 | 600/400-600/400 | Supply Air | Mechanical Supply Air 2 | 7191 | PSet_Revit_Dimensions - Angle: 90 deg; Duct Width: 1.9685; Duct Height: 1.31234; Max Segmentation Angle: 22.5 deg; Gores: 5; Center Radius: 2.95276; PSet_Revit_Mechanical - ASHRAE Table: CF3-1; PSet_Revit_Other - Length 3: 3.1168; Length 2: 2.95276; Length 1: 2.95276; End Length: 0.164042; Length 5: 0.164042; Length 4: 1.00447e-17
M_Rectangular Takeoff:Standard:Standard:1090926 | 2C19 | Level 2 | Level : Level 2 | 4 | 0.984252 | 0.82021 | 300x250-300x250 | Return Air | Mechanical Return Air 2 | 254 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.984252; W0: 0.984252; Length Multiplier: 0.25; H1: 0.82021; H0: 0.82021; ConnectorOffset: 0
M_Rectangular Tee:Standard:Standard:567364 | 1BC4 | Level 1 | Level : Level 1 | 3.3 | 0.328084 | 0.984252 | 300x300-100x300-100x300 | Supply Air | Mechanical Supply Air 1 | 1782 | PSet_Revit_Dimensions - Width: 0.328084; Length1: 0.574147; Height: 0.984252; Width3: 0.984252; Shoulder: 0.082021; Lining Width3: 0.984252; Length3a: 0.164042; Length3: 0.246063; Length1a: 0.492126; Insulation Width3: 0.984252
M_Round Takeoff:Standard:Standard:567528 | 1B17 | Level 1 | Level : Level 1 | 3.5 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 2324 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:566946 | 1CC1 | Level 2 | Level : Level 2 | -0.93 | 3.77297 | 1.31234 | 1150x400-1150x400-350x400 | Return Air | Mechanical Return Air 1 | 907 | PSet_Revit_Dimensions - Width: 3.77297; Length1: 0.656168; Height: 1.31234; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 1.88648; Length3: 1.9685; Length1a: 0.574147; Insulation Width3: 1.14829
M_Round Takeoff:Standard:Standard:568786 | 1E04 | Level 1 | Level : Level 1 | 3.3 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 5587 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569551 | 2DC1 | Roof - Main | Level : Roof - Main | -1.0895 |  |  | 400ø-400ø | Supply Air | Mechanical Supply Air 2 | 7251 | 0.328084 | 0.475648 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.656168; Lining Diameter: 1.31234; Insulation Diameter: 1.31234; Diameter: 1.31234
M_Rectangular Tee:Standard:Standard:566916 | 1A06 | Level 2 | Level : Level 2 | -0.93 | 0.82021 | 1.9685 | 300x600-250x600-250x600 | Return Air | Mechanical Return Air 1 | 827 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.574147; Height: 1.9685; Width3: 0.984252; Shoulder: 0.082021; Lining Width3: 0.984252; Length3a: 0.410105; Length3: 0.492126; Length1a: 0.492126; Insulation Width3: 0.984252; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Round Takeoff:Standard:Standard:569421 | 2AC4 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6849 | 0.328084 | 0.122978 | 0.328205 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:566749 | 1E14 | Level 2 | Level : Level 2 | -0.755 | 2.29659 | 0.82021 | 700x250-700x250-350x250 | Return Air | Mechanical Return Air 1 | 283 | PSet_Revit_Dimensions - Width: 2.29659; Length1: 0.656168; Height: 0.82021; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 1.14829; Length3: 1.23031; Length1a: 0.574147; Insulation Width3: 1.14829; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Oval Transition - Length:Standard:Standard:569516 | 2DC2 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 1400/400-1000/400 | Supply Air | Mechanical Supply Air 2 | 7181 | PSet_Revit_Other - Length 1: 1.31234; Width Offset: 10.6562; Width 1: 1.31234; Vertical Profile Offset: 0; Horizontal Profile Offset: 0.656168; Height Offset: 10; Height 1: 0; Half Width 2: 1.64042; Half Width 1: 2.29659; Half Height 2: 0.656168; Half Height 1: 0.656168; Height 2: 0; Width 2: 0.656168; PSet_Revit_Dimensions - Duct Width 2: 3.28084; Duct Width 1: 4.59318; Lining Duct Width 2: 3.28084; Lining Duct Width 1: 4.59318; Lining Duct Height 2: 1.31234; Lining Duct Height 1: 1.31234; Duct Length: 1.47638; Insulation Duct Width 2: 3.28084; Insulation Duct Width 1: 4.59318; Insulation Duct Height 2: 1.31234; Insulation Duct Height 1: 1.31234; Duct Height 2: 1.31234; Duct Height 1: 1.31234; OffsetHeight: 0.656168; OffsetWidth: 2.95276
M_Round Takeoff:Standard:Standard:570420 | 2C04 | Level 2 | Level : Level 2 | 3.6095 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 2 | 8949 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Round Takeoff:Standard:Standard:569472 | 2A08 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 2 | 7026 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Round Takeoff:Standard:Standard:568778 | 1EC2 | Level 1 | Level : Level 1 | 3.5 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 5582 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569612 | 2BC3 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 7435 | 0.328084 | 0.067884 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Oval to Round Transition - Length:Standard:Standard:569076 | 2AC3 | Roof - Main | Level : Roof - Main | -1.08 | 1.9685 | 1.31234 | 600/400-400ø | Supply Air | Mechanical Supply Air 2 | 5909 | PSet_Revit_Dimensions - Duct Width: 1.9685; Duct Height: 1.31234; Duct Length: 0.984252; OffsetHeight: 0.656168; OffsetWidth: 0.984252; Duct Radius: 0.656168; Lining Radius: 0.656168; Insulation Radius: 0.656168; Duct Diameter: 1.31234; PSet_Revit_Other - Length 1: 0.656168; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Vertical Profile Offset 2: 0.328084; Half Height: 0.656168; Vertical Profile Offset 1: 0.328084; Offset Width 1: 10; Offset Height 1: 10; Half Width: 0.984252
M_Rectangular Takeoff:Standard:Standard:567099 | 1E25 | Level 1 | Level : Level 1 | 3.79 | 1.31234 | 0.492126 | 400x150-400x150 | Return Air | Mechanical Return Air 1 | 1202 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.31234; W0: 1.31234; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568004 | 1A16 | Level 2 | Level : Level 2 | -0.87 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 3893 | 0.328084 | 0.129887 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:569589 | 2D18 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 7375 | 0.328084 | 0.10791 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:566804 | 1A07 | Level 2 | Level : Level 2 | -0.93 | 2.13255 | 1.14829 | 650x350-650x350-350x350 | Return Air | Mechanical Return Air 1 | 490 | PSet_Revit_Dimensions - Width: 2.13255; Length1: 0.656168; Height: 1.14829; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 1.06627; Length3: 1.14829; Length1a: 0.574147; Insulation Width3: 1.14829
M_Round Takeoff:Standard:Standard:567309 | 1E07 | Level 1 | Level : Level 1 | 3.5 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 1604 | 0.328084 | 0.141274 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:570012 | 2D08 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8395 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569393 | 2AC3 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6813 | 0.328084 | 0.10791 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569469 | 2A07 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 2 | 7020 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Round Takeoff:Standard:Standard:567764 | 1D34 | Level 1 | Level : Level 1 | 3.79 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 3093 | 0.328084 | 0.279609 | 0.396559 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:570202 | 2D05 | Roof - Main | Level : Roof - Main | -0.68 | 3.28084 | 1.31234 | 1000x400-1000x400 | Return Air | Mechanical Return Air 2 | 8755 | 0.82021 | 0.02 | 0.82021 | PSet_Revit_Dimensions - W1: 3.28084; W0: 3.28084; Length Multiplier: 0.25; H1: 1.31234; H0: 1.31234; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:570043 | 2BC3 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.656168 | 350x200-350x200 | Return Air | Mechanical Return Air 2 | 8488 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.656168; H0: 0.656168; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569418 | 2AC4 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 6844 | 0.328084 | 0.0859324 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:570414 | 2C09 | Level 2 | Level : Level 2 | 3.6095 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 2 | 8945 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Round Takeoff:Standard:Standard:567971 | 1A02 | Level 2 | Level : Level 2 | -0.860494 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 3759 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568137 | 1C18 | Level 2 | Level : Level 2 | -1.26049 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 4305 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:567882 | 1E23 | Level 1 | Level : Level 1 | 3.4095 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 3411 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Oval Elbow - Gored:Standard:Standard:569524 | 2D20 | Roof - Main | Level : Roof - Main | -1.08 | 1.9685 | 1.31234 | 600/400-600/400 | Supply Air | Mechanical Supply Air 2 | 7196 | PSet_Revit_Dimensions - Angle: 90 deg; Duct Width: 1.9685; Duct Height: 1.31234; Max Segmentation Angle: 22.5 deg; Gores: 5; Center Radius: 2.95276; PSet_Revit_Mechanical - ASHRAE Table: CF3-1; PSet_Revit_Other - Length 3: 3.1168; Length 2: 2.95276; Length 1: 2.95276; End Length: 0.164042; Length 5: 0.164042; Length 4: 1.00447e-17
M_Round Takeoff:Standard:Standard:568162 | 1D13 | Level 2 | Level : Level 2 | -0.869994 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 4371 | 0.328084 | 0.161725 | 0.38999 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:570431 | 2A03 | Level 2 | Level : Level 2 | 3.6095 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 8956 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Takeoff:Standard:Standard:567207 | 1C18 | Level 1 | Level : Level 1 | 3.64 | 1.31234 | 0.492126 | 400x150-400x150 | Return Air | Mechanical Return Air 1 | 1433 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.31234; W0: 1.31234; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569429 | 2AC3 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6863 | 0.328084 | 0.107918 | 0.328264 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569505 | Level 2 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 7160 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Oval Transition - Length:Standard:Standard:567899 | 1C10 | Level 2 | Level : Level 2 | -0.87 |  |  | 900/500-700/500 | Supply Air | Mechanical Supply Air 1 | 3452 | PSet_Revit_Other - Length 1: 0.656168; Width Offset: 10; Width 1: 0.656168; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Height Offset: 10; Height 1: 0; Half Width 2: 1.14829; Half Width 1: 1.47638; Half Height 2: 0.82021; Half Height 1: 0.82021; Height 2: 0; Width 2: 0; PSet_Revit_Dimensions - Duct Width 2: 2.29659; Duct Width 1: 2.95276; Lining Duct Width 2: 2.29659; Lining Duct Width 1: 2.95276; Lining Duct Height 2: 1.64042; Lining Duct Height 1: 1.64042; Duct Length: 0.984252; Insulation Duct Width 2: 2.29659; Insulation Duct Width 1: 2.95276; Insulation Duct Height 2: 1.64042; Insulation Duct Height 1: 1.64042; Duct Height 2: 1.64042; Duct Height 1: 1.64042; OffsetHeight: 0.82021; OffsetWidth: 1.47638
M_Round Takeoff:Standard:Standard:567974 | 1A02 | Level 2 | Level : Level 2 | -0.860494 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 3763 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:570428 | 2A14 | Level 2 | Level : Level 2 | 3.6095 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 8954 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular to Oval Transition - Length:Standard:Standard:567307 | 1E07 | Level 1 | Level : Level 1 | 3.50953 |  |  | 275x250-200/250 | Supply Air | Mechanical Supply Air 1 | 1599 | PSet_Revit_Other - Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Half Width 2: 0.328084; Half Width 1: 0.451115; Half Height 2: 0.410105; Half Height 1: 0.410105; Vertical Profile Offset 2: 0.205052; Vertical Profile Offset 1: 0.205052; Offset Width 1: 10; Offset Height 1: 10; PSet_Revit_Dimensions - Duct Width 2: 0.656168; Duct Width 1: 0.902231; Duct Length: 0.984252; Duct Height 2: 0.82021; Duct Height 1: 0.82021; OffsetHeight: 0.410105; OffsetWidth: 0.451115; Lining Width 2: 0.656168; Lining Height 2: 0.82021; Insulation Width 2: 0.656168; Insulation Height 2: 0.82021; Lining Width 1: 0.902231; Lining Height 1: 0.82021; Insulation Width 1: 0.902231; Insulation Height 1: 0.82021
M_Rectangular Takeoff:Standard:Standard:570002 | 2D09 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8387 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569495 | 2A11 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 7088 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:566780 | 1D21 | Level 2 | Level : Level 2 | -0.93 | 1.47638 | 0.656168 | 450x200-450x200-400x200 | Return Air | Mechanical Return Air 1 | 396 | PSet_Revit_Dimensions - Width: 1.47638; Length1: 0.738189; Height: 0.656168; Width3: 1.31234; Shoulder: 0.082021; Lining Width3: 1.31234; Length3a: 0.738189; Length3: 0.82021; Length1a: 0.656168; Insulation Width3: 1.31234; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Rectangular Tee:Standard:Standard:566876 | 1BC4 | Level 1 | Level : Level 1 | 3.3 | 3.28084 | 0.984252 | 1000x300-1000x300-200x300 | Return Air | Mechanical Return Air 1 | 760 | PSet_Revit_Dimensions - Width: 3.28084; Length1: 0.410105; Height: 0.984252; Width3: 0.656168; Shoulder: 0.082021; Lining Width3: 0.656168; Length3a: 1.64042; Length3: 1.72244; Length1a: 0.328084; Insulation Width3: 0.656168
M_Round Takeoff:Standard:Standard:567466 | 1B04 | Level 1 | Level : Level 1 | 3.69 |  |  | 350ø-350ø | Supply Air | Mechanical Supply Air 1 | 2192 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.574147; Lining Diameter: 1.14829; Insulation Diameter: 1.14829; Diameter: 1.14829
M_Round Takeoff:Standard:Standard:569846 | 2B3 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 2 | 8043 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Round Takeoff:Standard:Standard:569361 | 2CC1 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 6741 | 0.328084 | 0.240093 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:567925 | 1A07 | Level 2 | Level : Level 2 | -0.860493 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 3584 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569464 | 2A14 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 6971 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569438 | 2AC3 | Roof - Main | Level : Roof - Main | -1.1395 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6878 | 0.328084 | 0.250598 | 0.344209 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:569333 | 2C03 | Roof - Main | Level : Roof - Main | -0.68 | 1.47638 | 0.492126 | 450x150-450x150 | Return Air | Mechanical Return Air 2 | 6647 | 0.369094 | 0.02 | 0.369094 | PSet_Revit_Dimensions - W1: 1.47638; W0: 1.47638; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569795 | 2D18 | Roof - Main | Level : Roof - Main | -1.27999 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 7909 | 0.328084 | 0.154886 | 0.412362 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:566866 | 1B03 | Level 1 | Level : Level 1 | 3.3 | 0.984252 | 0.984252 | 300x300-300x300-250x300 | Return Air | Mechanical Return Air 1 | 736 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.492126; Height: 0.984252; Width3: 0.82021; Shoulder: 0.082021; Lining Width3: 0.82021; Length3a: 0.492126; Length3: 0.574147; Length1a: 0.410105; Insulation Width3: 0.82021
M_Round Takeoff:Standard:Standard:569413 | 2A14 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 6831 | 0.328084 | 0.240093 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:567966 | 1AC5 | Level 2 | Level : Level 2 | -0.87 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 3751 | 0.328084 | 0.192328 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Takeoff:Standard:Standard:570208 | 2D05 | Roof - Main | Level : Roof - Main | -0.78 | 2.29659 | 1.64042 | 700x500-700x500 | Return Air | Mechanical Return Air 2 | 8773 | 0.574147 | 0.0216054 | 0.575752 | PSet_Revit_Dimensions - W1: 2.29659; W0: 2.29659; Length Multiplier: 0.25; H1: 1.64042; H0: 1.64042; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:567181 | 1D16 | Level 1 | Level : Level 1 | 3.64 | 1.47638 | 0.82021 | 450x250-450x250 | Return Air | Mechanical Return Air 1 | 1395 | 0.369094 | 0.02 | 0.369094 | PSet_Revit_Dimensions - W1: 1.47638; W0: 1.47638; Length Multiplier: 0.25; H1: 0.82021; H0: 0.82021; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568014 | 1A16 | Level 2 | Level : Level 2 | -1.27 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 3943 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:567123 | 1E24 | Level 1 | Level : Level 1 | 3.79 | 1.64042 | 0.656168 | 500x200-500x200 | Return Air | Mechanical Return Air 1 | 1224 | 0.410105 | 0.02 | 0.410105 | PSet_Revit_Dimensions - W1: 1.64042; W0: 1.64042; Length Multiplier: 0.25; H1: 0.656168; H0: 0.656168; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569670 | 2B18 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 7563 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:569705 | 2D04-A | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 2 | 7685 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Round Takeoff:Standard:Standard:569786 | 2D14 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 7886 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Tee:Standard:Standard:567034 | 1DC6 | Level 1 | Level : Level 1 | 3.64 | 4.42913 | 1.47638 | 1350x450-1350x450-350x450 | Return Air | Mechanical Return Air 1 | 1068 | PSet_Revit_Dimensions - Width: 4.42913; Length1: 0.656168; Height: 1.47638; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 2.21457; Length3: 2.29659; Length1a: 0.574147; Insulation Width3: 1.14829
M_Rectangular Tee:Standard:Standard:566829 | 1DC1 | Level 2 | Level : Level 2 | -0.78 | 2.13255 | 0.984252 | 650x300-650x300-200x300 | Return Air | Mechanical Return Air 1 | 590 | PSet_Revit_Dimensions - Width: 2.13255; Length1: 0.410105; Height: 0.984252; Width3: 0.656168; Shoulder: 0.082021; Lining Width3: 0.656168; Length3a: 1.06627; Length3: 1.14829; Length1a: 0.328084; Insulation Width3: 0.656168; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Rectangular Tee:Standard:Standard:567347 | 1BC4 | Level 1 | Level : Level 1 | 3.3 | 0.492126 | 0.984252 | 300x300-150x300-150x300 | Supply Air | Mechanical Supply Air 1 | 1758 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.574147; Height: 0.984252; Width3: 0.984252; Shoulder: 0.082021; Lining Width3: 0.984252; Length3a: 0.246063; Length3: 0.328084; Length1a: 0.492126; Insulation Width3: 0.984252
M_Round Takeoff:Standard:Standard:567933 | 1A06 | Level 2 | Level : Level 2 | -1.25098 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 3633 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:569806 | 2D18 | Roof - Main | Level : Roof - Main | -1.27052 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 7943 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:570425 | 2A11 | Level 2 | Level : Level 2 | 3.6095 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 8952 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568635 | 1DC1 | Level 1 | Level : Level 1 | 3.20948 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5484 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569672 | 2BC2 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 7574 | 0.328084 | 0.163947 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:569269 | 2CC3 | Roof - Main | Level : Roof - Main | -1.18002 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6420 | 0.328084 | 0.02 | 0.416041 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:567145 | 1E06 | Level 1 | Level : Level 1 | 3.3 | 0.82021 | 0.492126 | 250x150-250x150 | Return Air | Mechanical Return Air 1 | 1305 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Rectangular Takeoff:Standard:Standard:569994 | 2D06 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8375 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569636 | 2BC4 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 7484 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:567058 | 1DC7 | Level 1 | Level : Level 1 | 3.64 | 4.42913 | 1.47638 | 1350x450-1350x450-1100x450 | Return Air | Mechanical Return Air 1 | 1099 | PSet_Revit_Dimensions - Width: 4.42913; Length1: 1.88648; Height: 1.47638; Width3: 3.60892; Shoulder: 0.082021; Lining Width3: 3.60892; Length3a: 2.21457; Length3: 2.29659; Length1a: 1.80446; Insulation Width3: 3.60892
M_Rectangular Tee:Standard:Standard:566955 | 1C08 | Level 1 | Level : Level 1 | 3.64 | 1.14829 | 0.656168 | 350x200-350x200-350x200 | Return Air | Mechanical Return Air 1 | 919 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.656168; Height: 0.656168; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 0.574147; Length3: 0.656168; Length1a: 0.574147; Insulation Width3: 1.14829
M_Oval Elbow - Mitered:Standard:Standard:570211 | 1D12 | Level 2 | Level : Level 2 | -0.87 | 1.64042 | 4.92126 | 500/1500-500/1500 | Supply Air | Mechanical Supply Air 1 | 8776 | PSet_Revit_Dimensions - Angle: 90 deg; Shoulder Length: 0.082021; Duct Width: 1.64042; Duct Height: 4.92126; PSet_Revit_Other - Length 3: 0.902231; Length 2: 0.902231; Length 1: 0.902231
M_Round Takeoff:Standard:Standard:567936 | 1AC5 | Level 2 | Level : Level 2 | -0.87 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 3642 | 0.328084 | 0.145317 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568179 | 1DC3 | Level 2 | Level : Level 2 | -0.87 |  |  | 500ø-500ø | Supply Air | Mechanical Supply Air 1 | 4417 | 0.410105 | 0.84021 | 0.410105 | PSet_Revit_Dimensions - Radius: 0.82021; Lining Diameter: 1.64042; Insulation Diameter: 1.64042; Diameter: 1.64042
M_Rectangular Takeoff:Standard:Standard:570023 | 2D06 | Roof - Main | Level : Roof - Main | -0.68 | 1.47638 | 0.492126 | 450x150-450x150 | Return Air | Mechanical Return Air 2 | 8406 | 0.369094 | 0.02 | 0.369094 | PSet_Revit_Dimensions - W1: 1.47638; W0: 1.47638; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569678 | 2D21 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 7580 | 0.328084 | 0.067884 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Tee:Standard:Standard:567019 | 1DC7 | Level 1 | Level : Level 1 | 3.64 | 4.42913 | 1.47638 | 1350x450-1350x450-350x450 | Return Air | Mechanical Return Air 1 | 1044 | PSet_Revit_Dimensions - Width: 4.42913; Length1: 0.656168; Height: 1.47638; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 2.21457; Length3: 2.29659; Length1a: 0.574147; Insulation Width3: 1.14829
M_Rectangular Tee:Standard:Standard:566758 | 1DC1 | Level 2 | Level : Level 2 | -0.93 | 2.13255 | 1.14829 | 650x350-650x350-350x350 | Return Air | Mechanical Return Air 1 | 341 | PSet_Revit_Dimensions - Width: 2.13255; Length1: 0.656168; Height: 1.14829; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 1.06627; Length3: 1.14829; Length1a: 0.574147; Insulation Width3: 1.14829; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Round Takeoff:Standard:Standard:568077 | 1C09 | Level 2 | Level : Level 2 | -1.21052 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 4103 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Takeoff:Standard:Standard:567193 | 1D16 | Level 1 | Level : Level 1 | 3.64 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 1 | 1408 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:567319 | 1E06 | Level 1 | Level : Level 1 | 3.79 |  |  | 350ø-350ø | Supply Air | Mechanical Supply Air 1 | 1652 | 0.328084 | 0.02 | 0.35878 | PSet_Revit_Dimensions - Radius: 0.574147; Lining Diameter: 1.14829; Insulation Diameter: 1.14829; Diameter: 1.14829
M_Round Takeoff:Standard:Standard:567993 | 1A16 | Level 2 | Level : Level 2 | -0.8605 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 3877 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:566740 | 1E14 | Level 2 | Level : Level 2 | -0.755 | 2.29659 | 0.82021 | 700x250-700x250-200x250 | Return Air | Mechanical Return Air 1 | 256 | PSet_Revit_Dimensions - Width: 2.29659; Length1: 0.410105; Height: 0.82021; Width3: 0.656168; Shoulder: 0.082021; Lining Width3: 0.656168; Length3a: 1.14829; Length3: 1.23031; Length1a: 0.328084; Insulation Width3: 0.656168; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Oval Elbow - Mitered:Standard:Standard:570224 | 1D32 | Level 2 | Level : Level 2 | -0.88 | 1.64042 | 4.92126 | 500/1500-500/1500 | Supply Air | Mechanical Supply Air 1 | 8798 | PSet_Revit_Dimensions - Angle: 90 deg; Shoulder Length: 0.082021; Duct Width: 1.64042; Duct Height: 4.92126; PSet_Revit_Other - Length 3: 0.902231; Length 2: 0.902231; Length 1: 0.902231
M_Round Takeoff:Standard:Standard:567400 | 1EC2 | Level 1 | Level : Level 1 | 3.5 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 1 | 1986 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Oval Transition - Length:Standard:Standard:569520 | 2DC1 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 900/400-600/400 | Supply Air | Mechanical Supply Air 2 | 7190 | PSet_Revit_Other - Length 1: 0.984252; Width Offset: 10; Width 1: 0.984252; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Height Offset: 10; Height 1: 0; Half Width 2: 0.984252; Half Width 1: 1.47638; Half Height 2: 0.656168; Half Height 1: 0.656168; Height 2: 0; Width 2: 0; PSet_Revit_Dimensions - Duct Width 2: 1.9685; Duct Width 1: 2.95276; Lining Duct Width 2: 1.9685; Lining Duct Width 1: 2.95276; Lining Duct Height 2: 1.31234; Lining Duct Height 1: 1.31234; Duct Length: 0.984252; Insulation Duct Width 2: 1.9685; Insulation Duct Width 1: 2.95276; Insulation Duct Height 2: 1.31234; Insulation Duct Height 1: 1.31234; Duct Height 2: 1.31234; Duct Height 1: 1.31234; OffsetHeight: 0.656168; OffsetWidth: 1.47638
M_Round Takeoff:Standard:Standard:569668 | 2B18 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 7553 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:569185 | 2CC5 | Roof - Main | Level : Roof - Main | -1.28 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 6208 | 0.328084 | 0.192328 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Cross:Standard:Standard:566856 | 1B08 | Level 1 | Level : Level 1 | 3.3 |  | 0.656168 | 350x200-350x200-300x200-300x200 | Return Air | Mechanical Return Air 1 | 711 | PSet_Revit_Dimensions - Length1: 0.656168; Height: 0.656168; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 0.492126; Length3: 0.574147; Length1a: 0.574147; Insulation Width3: 1.14829; Width4: 1.14829; Width1: 0.984252; Lining Width4: 1.14829; Lining Width1: 0.984252; Insulation Width4: 1.14829; Insulation Width1: 0.984252
M_Round Takeoff:Standard:Standard:569653 | 2B15 | Roof - Main | Level : Roof - Main | -1.0455 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 7517 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:569970 | 2D14 | Level 2 | Level : Level 2 | 3.725 | 0.984252 | 0.984252 | 300x300-300x300 | Return Air | Mechanical Return Air 2 | 8340 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.984252; W0: 0.984252; Length Multiplier: 0.25; H1: 0.984252; H0: 0.984252; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569338 | 2C24 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6654 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:567940 | 1A05 | Level 2 | Level : Level 2 | -0.860493 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 3648 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Tee:Standard:Standard:567745 | 1DC8 | Level 1 | Level : Level 1 | 3.30958 | 0.656168 | 0.82021 | 300x250-200x250-200x250 | Supply Air | Default Supply Air (cskender) | 2999 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.574147; Height: 0.82021; Width3: 0.984252; Shoulder: 0.082021; Lining Width3: 0.984252; Length3a: 0.328084; Length3: 0.410105; Length1a: 0.492126; Insulation Width3: 0.984252
M_Round Takeoff:Standard:Standard:569275 | 2CC2 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 6444 | 0.328084 | 0.067884 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569449 | 2AC3 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 2 | 6930 | 0.328084 | 0.242154 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Rectangular Takeoff:Standard:Standard:567759 | 1D40 | Level 1 | Level : Level 1 | 3.30951 | 0.492126 | 0.82021 | 150x250-150x250 | Supply Air | Mechanical Supply Air 1 | 3082 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.492126; W0: 0.492126; Length Multiplier: 0.25; H1: 0.82021; H0: 0.82021; ConnectorOffset: 0
M_Oval Transition - Length:Standard:Standard:567286 | 1E06 | Level 1 | Level : Level 1 | 3.69 |  |  | 1050/500-800/500 | Supply Air | Mechanical Supply Air 1 | 1551 | PSet_Revit_Other - Length 1: 0.82021; Width Offset: 10; Width 1: 0.82021; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Height Offset: 10; Height 1: 0; Half Width 2: 1.31234; Half Width 1: 1.72244; Half Height 2: 0.82021; Half Height 1: 0.82021; Height 2: 0; Width 2: 0; PSet_Revit_Dimensions - Duct Width 2: 2.62467; Duct Width 1: 3.44488; Lining Duct Width 2: 2.62467; Lining Duct Width 1: 3.44488; Lining Duct Height 2: 1.64042; Lining Duct Height 1: 1.64042; Duct Length: 0.984252; Insulation Duct Width 2: 2.62467; Insulation Duct Width 1: 3.44488; Insulation Duct Height 2: 1.64042; Insulation Duct Height 1: 1.64042; Duct Height 2: 1.64042; Duct Height 1: 1.64042; OffsetHeight: 0.82021; OffsetWidth: 1.72244
M_Oval Elbow - Gored:Standard:Standard:568081 | 1DC4 | Level 2 | Level : Level 2 | -1.32 | 1.64042 | 0.984252 | 500/300-500/300 | Supply Air | Mechanical Supply Air 1 | 4129 | PSet_Revit_Dimensions - Angle: 90 deg; Duct Width: 1.64042; Duct Height: 0.984252; Max Segmentation Angle: 22.5 deg; Gores: 5; Center Radius: 2.46063; PSet_Revit_Mechanical - ASHRAE Table: CF3-1; PSet_Revit_Other - Length 3: 2.46325; Length 2: 2.46063; Length 1: 2.46063; End Length: 0.00262467; Length 5: 0.00262467; Length 4: 1.60709e-19
M_Round Takeoff:Standard:Standard:567546 | 1B13 | Level 1 | Level : Level 1 | 3.79951 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 2359 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Takeoff:Standard:Standard:567273 | 1D25 | Level 1 | Level : Level 1 | 3.8 | 1.47638 | 0.492126 | 450x150-450x150 | Return Air | Mechanical Return Air 1 | 1501 | 0.369094 | 0.02 | 0.369094 | PSet_Revit_Dimensions - W1: 1.47638; W0: 1.47638; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568173 | 1C01 | Level 2 | Level : Level 2 | -1.27 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 4410 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Takeoff:Standard:Standard:570470 | 2D05 | Roof - Main | Level : Roof - Main | -3.78 | 2.46063 | 2.46063 | 750x750-750x750 | Supply Air | Mechanical Supply Air 2 | 9061 | 0.615157 | 0.02 | 0.615157 | PSet_Revit_Dimensions - W1: 2.46063; W0: 2.46063; Length Multiplier: 0.25; H1: 2.46063; H0: 2.46063; ConnectorOffset: 0
M_Rectangular Tee:Standard:Standard:566822 | 1A16 | Level 2 | Level : Level 2 | -1.325 | 1.80446 | 0.82021 | 550x250-550x250-250x250 | Return Air | Mechanical Return Air 1 | 572 | PSet_Revit_Dimensions - Width: 1.80446; Length1: 0.492126; Height: 0.82021; Width3: 0.82021; Shoulder: 0.082021; Lining Width3: 0.82021; Length3a: 0.902231; Length3: 0.984252; Length1a: 0.410105; Insulation Width3: 0.82021
M_Rectangular Takeoff:Standard:Standard:567135 | 1E09 | Level 1 | Level : Level 1 | 3.3 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 1 | 1258 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569824 | 2D18 | Roof - Main | Level : Roof - Main | -1.28 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 7986 | 0.328084 | 0.0754006 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Tee:Standard:Standard:568445 | 1D07 | Level 2 | Level : Level 2 | -0.860518 | 0.82021 | 0.82021 | 250x250-250x250-200x250 | Supply Air | Mechanical Supply Air 1 | 5236 | PSet_Revit_Dimensions - Width: 0.82021; Length1: 0.410105; Height: 0.82021; Width3: 0.656168; Shoulder: 0.082021; Lining Width3: 0.656168; Length3a: 0.410105; Length3: 0.492126; Length1a: 0.328084; Insulation Width3: 0.656168; PSet_Revit_Mechanical - ASHRAE Table: SR5-5
M_Rectangular Takeoff:Standard:Standard:569342 | 2CC1 | Roof - Main | Level : Roof - Main | -1.07048 | 0.82021 | 0.82021 | 250x250-250x250 | Supply Air | Mechanical Supply Air 2 | 6681 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.82021; W0: 0.82021; Length Multiplier: 0.25; H1: 0.82021; H0: 0.82021; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568135 | 1C18 | Level 2 | Level : Level 2 | -1.26049 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 4297 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569700 | 2D04-A | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 7670 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:567374 | 1EC1 | Level 1 | Level : Level 1 | 3.79 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 1812 | 0.328084 | 0.122972 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569877 | 2B10 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 8141 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568045 | 1C10 | Level 2 | Level : Level 2 | -0.860493 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 4040 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:566873 | 1B13 | Level 1 | Level : Level 1 | 3.3 | 3.28084 | 0.984252 | 1000x300-1000x300-450x300 | Return Air | Mechanical Return Air 1 | 751 | PSet_Revit_Dimensions - Width: 3.28084; Length1: 0.82021; Height: 0.984252; Width3: 1.47638; Shoulder: 0.082021; Lining Width3: 1.47638; Length3a: 1.64042; Length3: 1.72244; Length1a: 0.738189; Insulation Width3: 1.47638
M_Rectangular Takeoff:Standard:Standard:569960 | 2D17 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8326 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:568038 | 1C03 | Level 2 | Level : Level 2 | -0.87 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 4034 | 0.328084 | 0.0577795 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569821 | 2D10 | Roof - Main | Level : Roof - Main | -1.27049 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 7963 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:566863 | 1B04 | Level 1 | Level : Level 1 | 3.3 | 0.984252 | 0.82021 | 300x250-300x250-200x250 | Return Air | Mechanical Return Air 1 | 728 | PSet_Revit_Dimensions - Width: 0.984252; Length1: 0.410105; Height: 0.82021; Width3: 0.656168; Shoulder: 0.082021; Lining Width3: 0.656168; Length3a: 0.492126; Length3: 0.574147; Length1a: 0.328084; Insulation Width3: 0.656168
M_Rectangular Takeoff:Standard:Standard:569986 | 2D18 | Roof - Main | Level : Roof - Main | -0.68 | 2.13255 | 0.656168 | 650x200-650x200 | Return Air | Mechanical Return Air 2 | 8365 | 0.533136 | 0.02 | 0.533136 | PSet_Revit_Dimensions - W1: 2.13255; W0: 2.13255; Length Multiplier: 0.25; H1: 0.656168; H0: 0.656168; ConnectorOffset: 0
M_Rectangular Tee:Standard:Standard:566737 | 1E16 | Level 2 | Level : Level 2 | -0.755 | 1.80446 | 0.656168 | 550x200-550x200-350x200 | Return Air | Mechanical Return Air 1 | 247 | PSet_Revit_Dimensions - Width: 1.80446; Length1: 0.656168; Height: 0.656168; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 0.902231; Length3: 0.984252; Length1a: 0.574147; Insulation Width3: 1.14829; PSet_Revit_Mechanical - ASHRAE Table: ER5-2
M_Round Takeoff:Standard:Standard:568251 | 1DC1 | Level 2 | Level : Level 2 | -1.0605 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 4675 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:570335 | 2B15 | Level 2 | Level : Level 2 | 3.6095 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 8900 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:567779 | 1D36 | Level 1 | Level : Level 1 | 3.3096 | 0.492126 | 0.82021 | 150x250-150x250-150x250 | Supply Air | Mechanical Supply Air 1 | 3123 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Width3: 0.492126; Shoulder: 0.082021; Lining Width3: 0.492126; Length3a: 0.246063; Length3: 0.328084; Length1a: 0.246063; Insulation Width3: 0.492126
M_Round Takeoff:Standard:Standard:569879 | 2B11 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 2 | 8147 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:569873 | 2B7 | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 8103 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:566869 | 1B15 | Level 1 | Level : Level 1 | 3.3 | 1.14829 | 0.984252 | 350x300-350x300-250x300 | Return Air | Mechanical Return Air 1 | 742 | PSet_Revit_Dimensions - Width: 1.14829; Length1: 0.492126; Height: 0.984252; Width3: 0.82021; Shoulder: 0.082021; Lining Width3: 0.82021; Length3a: 0.574147; Length3: 0.656168; Length1a: 0.410105; Insulation Width3: 0.82021
M_Rectangular Tee:Standard:Standard:568440 | 1AC3 | Level 2 | Level : Level 2 | -0.8355 | 0.656168 | 0.984252 | 200x300-200x300-150x300 | Supply Air | Mechanical Supply Air 1 | 5233 | PSet_Revit_Dimensions - Width: 0.656168; Length1: 0.328084; Height: 0.984252; Width3: 0.492126; Shoulder: 0.082021; Lining Width3: 0.492126; Length3a: 0.328084; Length3: 0.410105; Length1a: 0.246063; Insulation Width3: 0.492126
M_Round Takeoff:Standard:Standard:569585 | 2D20 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 7366 | 0.328084 | 0.430105 | 0.738189 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Oval Elbow - Gored:Standard:Standard:567589 | 1E07 | Level 1 | Level : Level 1 | 3.69 | 3.44488 | 1.64042 | 1050/500-1050/500 | Supply Air | Mechanical Supply Air 1 | 2559 | PSet_Revit_Dimensions - Angle: 90 deg; Duct Width: 3.44488; Duct Height: 1.64042; Max Segmentation Angle: 22.5 deg; Gores: 5; Center Radius: 5.16732; PSet_Revit_Mechanical - ASHRAE Table: CF3-1; PSet_Revit_Other - Length 3: 5.33136; Length 2: 5.16732; Length 1: 5.16732; End Length: 0.164042; Length 5: 0.164042; Length 4: 1.00443e-17
M_Round Takeoff:Standard:Standard:569539 | 2BC3 | Roof - Main | Level : Roof - Main | -1.08948 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 7222 | 0.328084 | 0.272236 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:569702 | 2D04-A | Roof - Main | Level : Roof - Main | -1.0705 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 7679 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568670 | 1D25 | Level 1 | Level : Level 1 | 3.3 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5506 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:568448 | 1C04 | Level 2 | Level : Level 2 | -1.2105 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 5249 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Rectangular Tee:Standard:Standard:567784 | 1D36 | Level 1 | Level : Level 1 | 3.3096 | 0.492126 | 0.82021 | 150x250-150x250-150x250 | Supply Air | Mechanical Supply Air 1 | 3126 | PSet_Revit_Dimensions - Width: 0.492126; Length1: 0.328084; Height: 0.82021; Width3: 0.492126; Shoulder: 0.082021; Lining Width3: 0.492126; Length3a: 0.246063; Length3: 0.328084; Length1a: 0.246063; Insulation Width3: 0.492126
M_Rectangular Takeoff:Standard:Standard:570039 | 2BC6 | Roof - Main | Level : Roof - Main | -0.68 | 2.29659 | 1.14829 | 700x350-700x350 | Return Air | Mechanical Return Air 2 | 8475 | 0.574147 | 0.02 | 0.574147 | PSet_Revit_Dimensions - W1: 2.29659; W0: 2.29659; Length Multiplier: 0.25; H1: 1.14829; H0: 1.14829; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:567552 | 1BC2 | Level 1 | Level : Level 1 | 3.69 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 1 | 2369 | 0.328084 | 0.208056 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Rectangular Takeoff:Standard:Standard:570007 | 2D09 | Roof - Main | Level : Roof - Main | -0.68 | 1.14829 | 0.492126 | 350x150-350x150 | Return Air | Mechanical Return Air 2 | 8391 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.492126; H0: 0.492126; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:569268 | 2CC3 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 6416 | 0.328084 | 0.163947 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Rectangular Takeoff:Standard:Standard:569503 | 2A05 | Level 2 | Level : Level 2 | 3.875 | 0.984252 | 0.984252 | 300x300-300x300 | Return Air | Mechanical Return Air 2 | 7157 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 0.984252; W0: 0.984252; Length Multiplier: 0.25; H1: 0.984252; H0: 0.984252; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:1137261 | 2BC3 | Level 2 | Level : Level 2 | 3.6 |  |  | 250ø-250ø | Supply Air | Mechanical Supply Air 2 | 1310 | 0.328084 | 0.163947 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.410105; Lining Diameter: 0.82021; Insulation Diameter: 0.82021; Diameter: 0.82021
M_Round Takeoff:Standard:Standard:567506 | 1BC2 | Level 1 | Level : Level 1 | 3.4 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 2290 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Takeoff:Standard:Standard:567139 | 1E06 | Level 1 | Level : Level 1 | 3.3 | 1.14829 | 0.82021 | 350x250-350x250 | Return Air | Mechanical Return Air 1 | 1267 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - W1: 1.14829; W0: 1.14829; Length Multiplier: 0.25; H1: 0.82021; H0: 0.82021; ConnectorOffset: 0
M_Round Takeoff:Standard:Standard:567534 | 1BC2 | Level 1 | Level : Level 1 | 3.79 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 1 | 2336 | 0.328084 | 0.279529 | 0.39652 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569441 | 2AC3 | Roof - Main | Level : Roof - Main | -1.18 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6883 | 0.328084 | 0.0202638 | 0.416006 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:569435 | 2AC3 | Roof - Main | Level : Roof - Main | -1.1095 |  |  | 200ø-200ø | Supply Air | Mechanical Supply Air 2 | 6873 | 0.328084 | 0.168962 | 0.32834 | PSet_Revit_Dimensions - Radius: 0.328084; Lining Diameter: 0.656168; Insulation Diameter: 0.656168; Diameter: 0.656168
M_Round Takeoff:Standard:Standard:567736 | 1DC7 | Level 1 | Level : Level 1 | 3.35 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 2988 | 0.328084 | 0.168398 | 0.346131 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Tee:Standard:Standard:566960 | 1D13 | Level 2 | Level : Level 2 | -0.93 | 3.77297 | 1.31234 | 1150x400-1150x400-250x400 | Return Air | Mechanical Return Air 1 | 928 | PSet_Revit_Dimensions - Width: 3.77297; Length1: 0.492126; Height: 1.31234; Width3: 0.82021; Shoulder: 0.082021; Lining Width3: 0.82021; Length3a: 1.88648; Length3: 1.9685; Length1a: 0.410105; Insulation Width3: 0.82021
M_Oval Transition - Length:Standard:Standard:569074 | 2AC3 | Roof - Main | Level : Roof - Main | -1.08 |  |  | 700/400-600/400 | Supply Air | Mechanical Supply Air 2 | 5892 | PSet_Revit_Other - Length 1: 0.328084; Width Offset: 10; Width 1: 0.328084; Vertical Profile Offset: 0; Horizontal Profile Offset: 0; Height Offset: 10; Height 1: 0; Half Width 2: 0.984252; Half Width 1: 1.14829; Half Height 2: 0.656168; Half Height 1: 0.656168; Height 2: 0; Width 2: 0; PSet_Revit_Dimensions - Duct Width 2: 1.9685; Duct Width 1: 2.29659; Lining Duct Width 2: 1.9685; Lining Duct Width 1: 2.29659; Lining Duct Height 2: 1.31234; Lining Duct Height 1: 1.31234; Duct Length: 0.984252; Insulation Duct Width 2: 1.9685; Insulation Duct Width 1: 2.29659; Insulation Duct Height 2: 1.31234; Insulation Duct Height 1: 1.31234; Duct Height 2: 1.31234; Duct Height 1: 1.31234; OffsetHeight: 0.656168; OffsetWidth: 1.14829
M_Round Takeoff:Standard:Standard:568070 | 1C08 | Level 2 | Level : Level 2 | -1.21048 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 4083 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Rectangular Tee:Standard:Standard:566783 | 1CC1 | Level 2 | Level : Level 2 | -0.93 | 3.28084 | 1.14829 | 1000x350-1000x350-350x350 | Return Air | Mechanical Return Air 1 | 402 | PSet_Revit_Dimensions - Width: 3.28084; Length1: 0.656168; Height: 1.14829; Width3: 1.14829; Shoulder: 0.082021; Lining Width3: 1.14829; Length3a: 1.64042; Length3: 1.72244; Length1a: 0.574147; Insulation Width3: 1.14829
M_Round Takeoff:Standard:Standard:568140 | 1C18 | Level 2 | Level : Level 2 | -1.27 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 4313 | 0.328084 | 0.211948 | 0.349346 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:568783 | 1E04 | Level 1 | Level : Level 1 | 3.3 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 5585 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:567419 | 1BC3 | Level 1 | Level : Level 1 | 3.79 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 2070 | 0.328084 | 0.200643 | 0.427938 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
M_Round Takeoff:Standard:Standard:567387 | 1EC1 | Level 1 | Level : Level 1 | 3.79 |  |  | 300ø-300ø | Supply Air | Mechanical Supply Air 1 | 1866 | 0.328084 | 0.298416 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.492126; Lining Diameter: 0.984252; Insulation Diameter: 0.984252; Diameter: 0.984252
M_Round Takeoff:Standard:Standard:567396 | 1EC2 | Level 1 | Level : Level 1 | 3.5 |  |  | 150ø-150ø | Supply Air | Mechanical Supply Air 1 | 1930 | 0.328084 | 0.02 | 0.328084 | PSet_Revit_Dimensions - Radius: 0.246063; Lining Diameter: 0.492126; Insulation Diameter: 0.492126; Diameter: 0.492126
