Properties of the parts of a building model (IFC2X3), part 24 of 295

# IfcFlowFitting: Elbow - Generic (2063)
Name (M_Elbow - Generic:Elbow - Generic:Elbow - Generic:...) | In | Level | Host | Offset (m) | Mark | Tick Size | Nominal Radius | Nominal Diameter | Insulation Radius = Fitting Outside Radius | Fitting Outside Diameter | Center to End | Angle (deg) | Size | Center Radius | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | System Type | System Name
1062824 | 1CC1 | Level 1 | Level : Level 1 | 2.985 | 13503 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
713923 | Level 1 | Level 2 | Level : Level 2 | -1.35 | 9013 | 0.0120812 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.023731 | 45 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
663569 | 2B18 | Level 2 | Level : Level 2 | 2.9 | 4323 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
643345 | Level 1 | Level 1 | Level : Level 1 | 2.9 | 2714 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
643218 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2701 | 0.0293401 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0453046 | 45 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
717263 | 1CC1 | Level 2 | Level : Level 2 | -1.4 | 9328 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
633665 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1458 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1079790 | 1D28 | Level 1 | Level : Level 1 | 0.806263 | 14123 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
642107 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 2556 | 0.0224366 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0366752 | 45 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
708276 | Level 1 | Level 1 | Level : Level 1 | 0.688244 | 8362 | 0.0124762 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.0280714 | 61.8311 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1013902 | 1C10 | Level 1 | Level : Level 1 | 2.985 | 10950 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1124226 | 1B03 | Level 2 | Level : Level 2 | -1.35 | 15264 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
704655 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7911 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1078825 | Level 1 | Level 1 | Level : Level 1 | 0.371263 | 14058 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1027487 | 1B02 | Level 1 | Level : Level 1 | 2.985 | 11407 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
633670 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1462 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
639361 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 2202 | 0.0293401 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0453046 | 45 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
706254 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8082 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
703597 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7792 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
633601 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1443 | 0.0429976 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.0732914 | 86.3431 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
701504 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7515 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1013372 | 1C17 | Level 1 | Level : Level 1 | 2.985 | 10794 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
715256 | 1D08 | Level 2 | Level : Level 2 | -1.4 | 9114 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1080599 | Level 1 | Level 1 | Level : Level 1 | 0.371263 | 14203 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1061798 | 2D05 | Level 2 | Level : Level 2 | 0.381 | 13469 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
698895 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 7225 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
695920 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 6850 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1077098 | 1D07 | Level 1 | Level : Level 1 | 0.4 | 13903 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
702982 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 7717 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1068692 | Level 1 | Level 1 | Level : Level 1 | 2.9 | 13639 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Supply | Hydronic Supply 1
634525 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1597 | 0.0711969 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109936 | 90.2934 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
1026585 | 1E08 | Level 1 | Level : Level 1 | 2.985 | 11123 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
713333 | 1B10 | Level 2 | Level : Level 2 | -1.5 | 8932 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
711624 | 1C09 | Level 1 | Level : Level 1 | 0.2 | 8768 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1088264 | Level 2 | Roof - Main | Level : Roof - Main | -4.38 | 14818 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Storm
1070330 | 2D05 | Level 2 | Level : Level 2 | 4 | 13722 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Return | Hydronic Return 1
1067840 | TOF Footing | Level 1 | Level : Level 1 | -0.6 | 13559 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Return | Hydronic Return 1
1125989 | 1A16 | Level 2 | Level : Level 2 | -1.35 | 15431 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1061703 | 2D05 | Level 2 | Level : Level 2 | 1.74521 | 13443 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
703090 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7723 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1088651 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 14841 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Storm
702194 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7586 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
711232 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8723 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
707264 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8197 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
724049 | 1C05 | Level 1 | Level : Level 1 | 4.126 | 9744 | 0.0431472 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.0625635 | 45 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Undefined | Default Domestic Cold Water (cskender)
1052540 | 2AC4 | Level 2 | Level : Level 2 | 2.985 | 13149 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
635246 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 1732 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
642343 | 1E10 | Level 1 | Level : Level 1 | 2.9 | 2590 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
710532 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8632 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1052842 | 2A03 | Level 2 | Level : Level 2 | 2.985 | 13225 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
696421 | 1AC2 | Level 2 | Level : Level 2 | -1.5 | 6928 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1073577 | Level 2 | Level 2 | Level : Level 2 | 0.3 | 13767 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
641640 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 2490 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
707441 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 8240 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
637030 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1975 | 0.0567893 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0795911 | 44.8825 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
717306 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 9330 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
696388 | 2C24 | Level 2 | Level : Level 2 | 0.5 | 6921 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1078438 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 14034 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
712358 | 1B03 | Level 2 | Level : Level 2 | -1.35 | 8851 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
707413 | 1A09 | Level 1 | Level : Level 1 | 0.2 | 8233 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1013525 | 1C18 | Level 1 | Level : Level 1 | 2.985 | 10838 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1098423 | TOF Footing | Level 1 | Level : Level 1 | -0.501083 | 14936 | 0.104163 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151036 | 89.9977 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
639805 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 2270 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1079204 | 1D34 | Level 1 | Level : Level 1 | 0.3 | 14094 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
723439 | Level 2 | Level 2 | Level : Level 2 | 0.3 | 9715 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Storm
723437 | Level 2 | Level 2 | Level : Level 2 | 4.236 | 9713 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Storm
1084409 | 2C12 | Level 2 | Level : Level 2 | 0.2 | 14551 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1098425 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 14938 | 0.0303842 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.044057 | 32.5227 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
716842 | 2C19 | Level 2 | Level : Level 2 | 0.2 | 9276 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
642337 | Level 1 | Level 1 | Level : Level 1 | 2.9 | 2588 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
711334 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8751 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1077963 | 1D08 | Level 1 | Level : Level 1 | 0.806263 | 13994 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1083027 | 1A08 | Level 2 | Level : Level 2 | -1.5 | 14410 | 0.00550624 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.012389 | 29.6095 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
715832 | Level 1 | Level 2 | Level : Level 2 | -1.4 | 9186 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1128080 | 1BC2 | Level 1 | Level : Level 1 | 2.985 | 15582 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1068600 | TOF Footing | Level 1 | Level : Level 1 | -0.6 | 13620 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Supply | Hydronic Supply 1
1125643 | Level 1 | Level 2 | Level : Level 2 | -0.905 | 15385 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Storm
1061704 | 2D05 | Level 2 | Level : Level 2 | 1.74521 | 13444 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1096781 | 1E24 | Level 1 | Level : Level 1 | 0.2 | 14875 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
637641 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 2056 | 0.0212552 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0328205 | 33.4062 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1052822 | 2C03 | Level 2 | Level : Level 2 | 2.985 | 13221 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1068627 | TOF Footing | Level 1 | Level : Level 1 | -0.6 | 13625 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Supply | Hydronic Supply 1
1002291 | 1BC3 | Level 1 | Level : Level 1 | 2.985 | 10227 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1068607 | TOF Footing | Level 1 | Level : Level 1 | -0.6 | 13621 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Supply | Hydronic Supply 1
1127270 | 1D20 | Level 2 | Level : Level 2 | -1.55 | 15540 | 0.0362437 | 0.106627 | 0.213255 | 0.109375 | 0.21875 | 0.0539341 | 45 | 65 mmø-65 mmø | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1125999 | 1A16 | Level 2 | Level : Level 2 | -1.45 | 15439 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
710253 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8593 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
714650 | 1D07 | Level 2 | Level : Level 2 | -1.4 | 9069 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1026513 | 1E01 | Level 1 | Level : Level 1 | 2.985 | 11099 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1127879 | 1D05 | Level 1 | Level : Level 1 | 2.9 | 15573 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
710307 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8598 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1068690 | TOF Footing | Level 1 | Level : Level 1 | -0.6 | 13637 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Supply | Hydronic Supply 1
1070117 | 2D05 | Level 2 | Level : Level 2 | 4 | 13681 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Return | Hydronic Return 1
711233 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8724 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1118047 | 2C10 | Level 2 | Level : Level 2 | 0.860313 | 15124 | 0.00558244 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.0125605 | 30.0009 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1126077 | 1A16 | Level 2 | Level : Level 2 | -1.45 | 15448 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
692654 | Level 1 | Level 2 | Level : Level 2 | -1.5 | 6528 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
715620 | 1A05 | Level 2 | Level : Level 2 | -1.35 | 9152 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1150910 | 2CS3 | Level 2 | Level : Level 2 | 4.236 | 15708 | 0.0375 | 0.131234 | 0.262467 | 0.046875 | 0.09375 | 0.0677083 | 90 | 80 mmø-80 mmø | 0.0677083 |  |  |  |  |  |  | Sanitary | Storm
707309 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8210 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1081208 | TOF Footing | Level 1 | Level : Level 1 | -0.35 | 14261 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1113507 | 1A05 | Level 1 | Level : Level 1 | 2.985 | 15089 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
722275 | 2D05 | Level 2 | Level : Level 2 | 4.236 | 9635 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Storm
707403 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8229 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1127882 | 1D05 | Level 1 | Level : Level 1 | 3.56 | 15576 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1086469 | Level 1 | Level 1 | Level : Level 1 | 0.908719 | 14696 | 0.0166667 | 0.0164042 | 0.0328084 | 0.0208333 | 0.0416667 | 0.0416667 | 90 | 10 mmø-10 mmø | 0.0416667 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
697172 | 1A05 | Level 2 | Level : Level 2 | -1.5 | 7011 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1082326 | 1CC1 | Level 2 | Level : Level 2 | 0.1 | 14348 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1151025 | 1D21 | Level 1 | Level : Level 1 | 3.97 | 15720 | 0.0375 | 0.246063 | 0.492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 150 mmø-150 mmø | 0.0677083 |  |  |  |  |  |  | Sanitary | Storm
1078327 | Level 1 | Level 1 | Level : Level 1 | 0.806263 | 14032 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
644019 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2786 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
707404 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8230 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
724933 | Level 1 | Level 2 | Level : Level 2 | -4.27 | 9812 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Storm
700888 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 7450 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
641202 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 2432 | 0.00955104 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0156123 | 20 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1081532 | 2C14 | Level 2 | Level : Level 2 | 0.3 | 14286 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
724932 | Level 1 | Level 2 | Level : Level 2 | -0.444 | 9811 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Storm
999044 | Level 2 | Level 2 | Level : Level 2 | 3.1 | 10045 | 0.0375 | 0.0656168 | 0.131234 | 0.046875 | 0.09375 | 0.0677083 | 90 | 40 mmø-40 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
642401 | 1E12 | Level 1 | Level : Level 1 | 2.9 | 2599 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
712806 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 8877 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
714001 | 1DC6 | Level 1 | Level : Level 1 | 3.17 | 9024 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1081533 | Level 2 | Level 2 | Level : Level 2 | 0.3 | 14287 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
634604 | Level 1 | Level 1 | Level : Level 1 | 0 | 1615 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
665863 | 1DC3 | Level 2 | Level : Level 2 | -1.6882 | 4561 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1068540 | Level 1 | Level 1 | Level : Level 1 | 0.571 | 13617 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Supply | Hydronic Supply 1
639828 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 2275 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1113514 | 1A05 | Level 1 | Level : Level 1 | 2.985 | 15090 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1128081 | 1BC2 | Level 1 | Level : Level 1 | 2.985 | 15583 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
704933 | TOF Footing | Level 1 | Level : Level 1 | -0.25 | 7923 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1086109 | Level 2 | Level 2 | Level : Level 2 | 0.5 | 14681 | 0.0166667 | 0.0164042 | 0.0328084 | 0.0208333 | 0.0416667 | 0.0416667 | 90 | 10 mmø-10 mmø | 0.0416667 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1127880 | 1D05 | Level 1 | Level : Level 1 | 3.56 | 15574 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
686018 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5756 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
695308 | 1CC1 | Level 2 | Level : Level 2 | -1.5 | 6797 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1123093 | 1B08 | Level 2 | Level : Level 2 | -1.5 | 15214 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
715347 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 9134 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1050155 | 2B21 | Level 2 | Level : Level 2 | 2.985 | 12535 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1077639 | 1D08 | Level 1 | Level : Level 1 | 0 | 13979 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1068653 | TOF Footing | Level 1 | Level : Level 1 | -0.6 | 13635 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Supply | Hydronic Supply 1
664990 | Level 2 | Level 2 | Level : Level 2 | 3.1 | 4482 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1084864 | 2C17 | Level 2 | Level : Level 2 | 0.2 | 14590 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
637011 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1972 | 0.0567496 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0795354 | 44.8542 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
634372 | Level 1 | Level 1 | Level : Level 1 | 0.232932 | 1556 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
702647 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 7665 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
634778 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1636 | 0.0431472 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.0625635 | 45 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
663231 | 1C18 | Level 1 | Level : Level 1 | 3 | 4307 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1028233 | 1DC3 | Level 1 | Level : Level 1 | 2.985 | 11615 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1111449 | 2D05 | Level 2 | Level : Level 2 | 1.74521 | 15057 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1085891 | Level 1 | Level 2 | Level : Level 2 | -1.6882 | 14660 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1150832 | 2D05 | Roof - Main | Level : Roof - Main | -0.905 | 15695 | 0.0375 | 0.164042 | 0.328084 | 0.046875 | 0.09375 | 0.0677083 | 90 | 100 mmø-100 mmø | 0.0677083 |  |  |  |  |  |  | Sanitary | Storm
1150782 | 2D13 | Level 2 | Level : Level 2 | 4.162 | 15683 | 0.0375 | 0.246063 | 0.492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 150 mmø-150 mmø | 0.0677083 |  |  |  |  |  |  | Sanitary | Default Sanitary (cskender)
1083678 | 1A03 | Level 2 | Level : Level 2 | -1.6882 | 14488 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
704622 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 7907 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
685185 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5660 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
663567 | Level 2 | Level 1 | Level : Level 1 | 7.47 | 4321 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
1125997 | 1A16 | Level 2 | Level : Level 2 | -1.45 | 15437 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
635394 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1774 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
634558 | 1B02 | Level 1 | Level : Level 1 | 0 | 1609 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
1068589 | TOF Footing | Level 1 | Level : Level 1 | -0.6 | 13619 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Supply | Hydronic Supply 1
709852 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8566 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
633269 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1403 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1124711 | 1E11 | Level 2 | Level : Level 2 | -1.4 | 15311 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
663307 | 1C04 | Level 1 | Level : Level 1 | 2.9 | 4310 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
642008 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2531 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
634605 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1616 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
1084528 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 14572 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1086677 | Level 1 | Level 1 | Level : Level 1 | 0.873 | 14729 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
702291 | 1D26 | Level 1 | Level : Level 1 | 0.3 | 7601 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1012418 | 1E25 | Level 1 | Level : Level 1 | 2.985 | 10494 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1098241 | Level 1 | Level 1 | Level : Level 1 | 0.355525 | 14912 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1124228 | 1B03 | Level 2 | Level : Level 2 | -1.45 | 15266 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
641266 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 2451 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
705762 | TOF Footing | Level 1 | Level : Level 1 | -0.25 | 8037 | 0.0189848 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.0323604 | 45 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1122940 | 1B08 | Level 2 | Level : Level 2 | -1.5 | 15200 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
702645 | 1D40 | Level 1 | Level : Level 1 | 0.3 | 7663 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1124261 | 1B03 | Level 2 | Level : Level 2 | -1.35 | 15271 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
703091 | TOF Footing | Level 1 | Level : Level 1 | -0.35 | 7724 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1029827 | 2B16 | Level 2 | Level : Level 2 | 2.985 | 11794 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1126310 | 1CC1 | Level 2 | Level : Level 2 | -1.5 | 15471 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
634263 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1536 | 0.055776 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0781709 | 44.1593 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
698900 | Level 2 | Level 2 | Level : Level 2 | 0.9144 | 7230 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1085204 | 1D16 | Level 2 | Level : Level 2 | -0.5 | 14623 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
702724 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 7680 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
701132 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 7480 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1126842 | 1D16 | Level 2 | Level : Level 2 | -1.6882 | 15512 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
640678 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2408 | 0.0568245 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0796405 | 44.9076 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
696390 | Level 2 | Level 2 | Level : Level 2 | 0.5 | 6923 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
702981 | TOF Footing | Level 1 | Level : Level 1 | -0.35 | 7716 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1098087 | Level 1 | Level 1 | Level : Level 1 | 0.355525 | 14899 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1098240 | Level 1 | Level 1 | Level : Level 1 | 0.355525 | 14911 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1097993 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 14881 | 0.102074 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.148008 | 88.8376 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
641369 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 2464 | 0.0224366 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0366752 | 45 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1086113 | Level 2 | Level 2 | Level : Level 2 | 0.908719 | 14685 | 0.0166667 | 0.0164042 | 0.0328084 | 0.0208333 | 0.0416667 | 0.0416667 | 90 | 10 mmø-10 mmø | 0.0416667 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
724570 | 1B10 | Level 2 | Level : Level 2 | -0.444 | 9785 | 0.0845686 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.11434 | 45 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Storm
641608 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2479 | 0.0293401 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0453046 | 45 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1079705 | 1D32 | Level 1 | Level : Level 1 | 0.4 | 14111 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1026493 | 1BC4 | Level 1 | Level : Level 1 | 2.985 | 11095 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
695383 | 1D04 | Level 2 | Level : Level 2 | -1.5 | 6815 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1013709 | 1C05 | Level 1 | Level : Level 1 | 2.985 | 10890 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
712998 | 1B09 | Level 1 | Level : Level 1 | 3.14 | 8891 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1127594 | 1D13 | Level 2 | Level : Level 2 | -0.8755 | 15562 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
706743 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 8125 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
718418 | Level 1 | Level 2 | Level : Level 2 | -1.4 | 9399 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1125644 | 1B02 | Level 2 | Level : Level 2 | -0.905 | 15386 | 0.0279114 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.0404715 | 30 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Storm
