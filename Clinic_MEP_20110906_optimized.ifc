Properties of the parts of a building model (IFC2X3), part 278 of 295

# IfcFlowSegment: Round Duct:Taps / Short Radius:569225
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569227
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569227
PSet_Revit_Identity Data - Mark: 1287
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.275 m; Top Elevation: 3.525 m; Size Lock: no; Loss Coefficient: 0.0506866; Hydraulic Diameter: 0.82021; Section: 352; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.600339 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.764375 m
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 0.696365; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.4 m; Start Offset: 3.4 m; End Offset: 3.4 m; Slope: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569229
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569229
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.4 m; Start Offset: 3.4 m; End Offset: 3.4 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.275 m; Top Elevation: 3.525 m; Size Lock: no; Loss Coefficient: 0.0496589; Hydraulic Diameter: 0.82021; Section: 352; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.588167 m2
PSet_Revit_Identity Data - Mark: 1288
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.748878 m
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 0.682247; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569236
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569236
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.49998 m; Start Offset: 3.49998 m; End Offset: 3.49998 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.39998 m; Top Elevation: 3.59998 m; Size Lock: no; Loss Coefficient: 0.0708402; Hydraulic Diameter: 0.656168; Section: 353; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.562345 m2
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 2.3761; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.895 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1291
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569237
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569237
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 2.3761; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Identity Data - Mark: 1292
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.49998 m; Start Offset: 3.49998 m; End Offset: 3.49998 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.39998 m; Top Elevation: 3.59998 m; Size Lock: no; Loss Coefficient: 0.0708402; Hydraulic Diameter: 0.656168; Section: 356; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.562345 m2
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.895 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569238
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569238
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.6 m; Size Lock: no; Loss Coefficient: 0.0708402; Hydraulic Diameter: 0.656168; Section: 359; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.562345 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1293
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.5 m; Start Offset: 3.5 m; End Offset: 3.5 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 2.3761; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.895 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569239
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569239
PSet_Revit_Identity Data - Mark: 1294
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.39998 m; Top Elevation: 3.59998 m; Size Lock: no; Loss Coefficient: 0.0708402; Hydraulic Diameter: 0.656168; Section: 362; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.562345 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.49998 m; Start Offset: 3.49998 m; End Offset: 3.49998 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 2.3761; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.895 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569240
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569240
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 0.797147; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.475 m; Top Elevation: 3.725 m; Size Lock: no; Loss Coefficient: 0.0580222; Hydraulic Diameter: 0.82021; Section: 78; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.687223 m2
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.875 m
PSet_Revit_Identity Data - Mark: 1295
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569241
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569241
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.475 m; Top Elevation: 3.725 m; Size Lock: no; Loss Coefficient: 0.153353; Hydraulic Diameter: 0.82021; Section: 365; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.81633 m2
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 2.31262 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 2.10686; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Identity Data - Mark: 1296
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569242
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569242
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 78.9045; Friction: 3.21519; Pressure Drop: 26.5543; Velocity Pressure: 106.008; Reynolds number: 240374
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 2.51736 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.525 m; Top Elevation: 3.675 m; Size Lock: no; Loss Coefficient: 0.250493; Hydraulic Diameter: 0.492126; Section: 368; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.18628 m2
PSet_Revit_Identity Data - Mark: 1297
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569243
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569243
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.917355 m
PSet_Revit_Identity Data - Mark: 1298
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 0.835734; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.475 m; Top Elevation: 3.725 m; Size Lock: no; Loss Coefficient: 0.0608309; Hydraulic Diameter: 0.82021; Section: 93; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.720489 m2
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569244
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569244
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Size Lock: no; Loss Coefficient: 0.0364353; Hydraulic Diameter: 1.31234; Section: 109; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.25664 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Dimensions - Size: 400ø; Diameter: 1.31234; Length: 1 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1299
PSet_Revit_Mechanical - Airflow - Flow: 45.0262; Additional Flow: 0; Velocity: 33.2878; Friction: 0.209529; Pressure Drop: 0.687432; Velocity Pressure: 18.8672; Reynolds number: 270420
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569246
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569246
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.45 m; Top Elevation: 3.75 m; Size Lock: no; Loss Coefficient: 0.183057; Hydraulic Diameter: 0.984252; Section: 114; Insulation Thickness: 0; Lining Thickness: 0; Area: 3.46765 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Dimensions - Size: 300ø; Diameter: 0.984252; Length: 3.67929 m
PSet_Revit_Mechanical - Airflow - Flow: 30.0175; Additional Flow: 0; Velocity: 39.4522; Friction: 0.401898; Pressure Drop: 4.85138; Velocity Pressure: 26.502; Reynolds number: 240374
PSet_Revit_Identity Data - Mark: 1300
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569248
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569248
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 1.31929 m
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 3.50253; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Identity Data - Mark: 1301
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5 m; Top Elevation: 3.7 m; Size Lock: no; Loss Coefficient: 0.104423; Hydraulic Diameter: 0.656168; Section: 371; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.828934 m2
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569250
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569250
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 0.758546; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5 m; Top Elevation: 3.7 m; Size Lock: no; Loss Coefficient: 0.0226151; Hydraulic Diameter: 0.656168; Section: 371; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.179523 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.28572 m
PSet_Revit_Identity Data - Mark: 1302
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569251
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569251
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.41572 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.475 m; Top Elevation: 3.725 m; Size Lock: no; Loss Coefficient: 0.0275669; Hydraulic Diameter: 0.82021; Section: 113; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.326506 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1303
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 0.378732; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569252
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569252
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 0.877779; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.963506 m
PSet_Revit_Identity Data - Mark: 1304
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.475 m; Top Elevation: 3.725 m; Size Lock: no; Loss Coefficient: 0.0638912; Hydraulic Diameter: 0.82021; Section: 108; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.756736 m2
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569254
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569254
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 28.4056; Friction: 0.277681; Pressure Drop: 0.508626; Velocity Pressure: 13.7387; Reynolds number: 144224
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.475 m; Top Elevation: 3.725 m; Size Lock: no; Loss Coefficient: 0.0370215; Hydraulic Diameter: 0.82021; Section: 108; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.438488 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1305
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.5583 m
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569300
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569300
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1327
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 10.9074; Friction: 0.0404908; Pressure Drop: 0.0432069; Velocity Pressure: 2.02571; Reynolds number: 66456.3
PSet_Revit_Dimensions - Size: 300ø; Diameter: 0.984252; Length: 0.325246 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4595 m; Top Elevation: 3.7595 m; Size Lock: no; Loss Coefficient: 0.0213293; Hydraulic Diameter: 0.984252; Section: 30; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.306537 m2
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569303
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569303
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.059602 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5095 m; Top Elevation: 3.7095 m; Size Lock: no; Loss Coefficient: 0.00533754; Hydraulic Diameter: 0.656168; Section: 86; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.0374491 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1330
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.279922; Pressure Drop: 0.0547373; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569305
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569305
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6095 m; Start Offset: 3.6095 m; End Offset: 3.6095 m; Slope: 0
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.415903 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 1.51533; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Identity Data - Mark: 1332
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.5345 m; Top Elevation: 3.6845 m; Size Lock: no; Loss Coefficient: 0.0467531; Hydraulic Diameter: 0.492126; Section: 75; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.19599 m2
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569307
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569307
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 3.20756; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.35 m; Start Offset: 3.35 m; End Offset: 3.35 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1333
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.880359 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.275 m; Top Elevation: 3.425 m; Size Lock: no; Loss Coefficient: 0.0989641; Hydraulic Diameter: 0.492126; Section: 75; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.414859 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569308
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569308
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.56557 m; Start Offset: 3.56557 m; End Offset: 3.39393 m; Slope: 1
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 0.242724 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 0.884359; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Identity Data - Mark: 1334
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.3409 m; Top Elevation: 3.6186 m; Size Lock: no; Loss Coefficient: 0.0272855; Hydraulic Diameter: 0.492126; Section: 75; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.114381 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Round Duct:Taps / Short Radius:569311
In: Level 2
Type - ElementType: Round Duct:Taps / Short Radius:569311
