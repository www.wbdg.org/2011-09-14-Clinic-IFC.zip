Properties of the parts of a building model (IFC2X3), part 54 of 295

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570278
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 166
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.26071 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.435335; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570281
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570281
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Identity Data - Mark: 167
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 4.97351; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.14352 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.15345; Hydraulic Diameter: 0.492126; Section: 133; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570283
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570283
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Identity Data - Mark: 168
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.08658; Hydraulic Diameter: 0.984252; Section: 66; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 10.9074; Friction: 0.0432181; Pressure Drop: 0.175386; Velocity Pressure: 2.02571; Reynolds number: 66456.3
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Diameter: 0.984252; Length: 1.23693 m
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570286
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570286
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.133802; Hydraulic Diameter: 0.656168; Section: 144; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.32415 m
PSet_Revit_Identity Data - Mark: 169
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.37216; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570288
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570288
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 10.9074; Friction: 0.0432181; Pressure Drop: 0.163053; Velocity Pressure: 2.02571; Reynolds number: 66456.3
PSet_Revit_Dimensions - Diameter: 0.984252; Length: 1.14995 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 170
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.0804918; Hydraulic Diameter: 0.984252; Section: 36; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570290
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570290
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.100432; Hydraulic Diameter: 0.984252; Section: 38; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 10.9074; Friction: 0.0432181; Pressure Drop: 0.203445; Velocity Pressure: 2.02571; Reynolds number: 66456.3
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Diameter: 0.984252; Length: 1.43482 m
PSet_Revit_Identity Data - Mark: 171
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570292
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570292
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 5.65698; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.174537; Hydraulic Diameter: 0.492126; Section: 46; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.30066 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 172
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570294
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570294
PSet_Revit_Identity Data - Mark: 173
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Dimensions - Diameter: 0.984252; Length: 1.46093 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.102259; Hydraulic Diameter: 0.984252; Section: 40; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 10.9074; Friction: 0.0432181; Pressure Drop: 0.207148; Velocity Pressure: 2.02571; Reynolds number: 66456.3
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570296
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570296
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.102737; Hydraulic Diameter: 0.82021; Section: 42; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.24975 m
PSet_Revit_Identity Data - Mark: 174
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.431549; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570299
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570299
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 0.903594 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.0742811; Hydraulic Diameter: 0.82021; Section: 146; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.312018; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 175
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570301
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570301
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.20422; Hydraulic Diameter: 0.492126; Section: 64; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Identity Data - Mark: 176
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 6.61905; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.52186 m
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570303
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570303
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 177
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.654486; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.155811; Hydraulic Diameter: 0.82021; Section: 220; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.89537 m
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570305
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570305
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.545802; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.58062 m
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.129937; Hydraulic Diameter: 0.82021; Section: 229; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 178
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570307
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570307
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.56332; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.63136 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 179
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.134108; Hydraulic Diameter: 0.82021; Section: 213; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570309
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570309
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.451661; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.308 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.107525; Hydraulic Diameter: 0.82021; Section: 245; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 180
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570311
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570311
PSet_Revit_Identity Data - Mark: 181
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 6.1753; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.190529; Hydraulic Diameter: 0.492126; Section: 203; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.41983 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570313
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570313
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.54566; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 182
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.49157 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.15072; Hydraulic Diameter: 0.656168; Section: 233; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570315
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570315
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.3569; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.132314; Hydraulic Diameter: 0.656168; Section: 238; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.30942 m
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Identity Data - Mark: 183
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570318
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570318
PSet_Revit_Identity Data - Mark: 184
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.154959; Hydraulic Diameter: 0.656168; Section: 199; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.53352 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.58913; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570320
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570320
PSet_Revit_Identity Data - Mark: 185
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.33666 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.38513; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.135067; Hydraulic Diameter: 0.656168; Section: 201; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570323
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570323
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.32567; Pressure Drop: 7.21062; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.222472; Hydraulic Diameter: 0.492126; Section: 243; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Dimensions - Diameter: 0.492126; Length: 1.65788 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 186
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570325
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570325
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 0.981978; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.0957546; Hydraulic Diameter: 0.656168; Section: 211; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Identity Data - Mark: 187
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 0.947616 m
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570327
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570327
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Identity Data - Mark: 188
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.46317 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.505244; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.120281; Hydraulic Diameter: 0.82021; Section: 254; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570329
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570329
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.4863 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.513232; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Identity Data - Mark: 189
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.122183; Hydraulic Diameter: 0.82021; Section: 256; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570331
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570331
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Dimensions - Diameter: 0.82021; Length: 1.49739 m
PSet_Revit_Identity Data - Mark: 190
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.123095; Hydraulic Diameter: 0.82021; Section: 261; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.10525; Pressure Drop: 0.517061; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Preferred Junction Type: 1; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Union: M_Round Union: Round Union

# IfcFlowSegment: Flex Duct Round:Flex Duct - Round:570333
In: Level 2
Type - ElementType: Flex Duct Round:Flex Duct - Round:570333
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Diameter: 0.656168; Length: 1.22539 m
PSet_Revit_Identity Data - Mark: 191
PSet_Revit_Graphics - Flex Pattern: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Reference Level: Level 2
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Size Lock: no; Loss Coefficient: 0.123823; Hydraulic Diameter: 0.656168; Section: 404; Insulation Thickness: 0; Lining Thickness: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 24.5416; Friction: 0.315853; Pressure Drop: 1.26982; Velocity Pressure: 10.2552; Reynolds number: 99684.4
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 24; Classification Description: Flexible Ducts; ModelLabel: ModelLabel
