Properties of the parts of a building model (IFC2X3), part 82 of 295

# IfcFlowSegment: Pipe Types:Cold Water:690424
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690424
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 2.25; Insulation Thickness: 0; Invert Elevation: -0.40533 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 71747.2; Section: 422; Area: 0.14795 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 2204
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 3.1396 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690431
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690431
PSet_Revit_Identity Data - Mark: 2205
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.0833333; Inner Diameter: 0.0740157; Size: 25 mmø; Diameter: 0.082021; Length: 2.83003 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: -0.41128 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 8881.89; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 536; Area: 0.22227 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690462
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690462
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.385713 m; Start Offset: -0.385713 m; End Offset: 0.341238 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 2.25; Insulation Thickness: 0; Invert Elevation: -0.385713 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 16612.5; Section: 422; Area: 0.0342567 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 2207
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.72695 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690483
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690483
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 2208
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.266996 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 2.25; Insulation Thickness: 0; Invert Elevation: -0.40533 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 6101.49; Section: 424; Area: 0.0125819 m2
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690504
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690504
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: -0.41128 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 8881.89; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 535; Area: 0.389216 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 2210
PSet_Revit_Dimensions - Outer Diameter: 0.0833333; Inner Diameter: 0.0740157; Size: 25 mmø; Diameter: 0.082021; Length: 4.95565 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690508
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690508
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: -0.40533 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 77832.3; Section: 79; Area: 0.160498 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 3.40587 m
PSet_Revit_Identity Data - Mark: 2211
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690547
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690547
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.742688 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: -0.385713 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 16972.2; Section: 79; Area: 0.0349983 m2
PSet_Revit_Identity Data - Mark: 2213
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.385713 m; Start Offset: -0.385713 m; End Offset: 0.356975 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690570
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690570
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.4604 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 0.38555 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 10521.2; Section: 79; Area: 0.0216958 m2
PSet_Revit_Identity Data - Mark: 2214
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.84595 m; Start Offset: 0.84595 m; End Offset: 0.38555 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690571
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690571
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.0834428 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 0.365933 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 1906.87; Section: 79; Area: 0.00393215 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.371263 m; Start Offset: 0.371263 m; End Offset: 0.371263 m; Slope: 0
PSet_Revit_Identity Data - Mark: 2215
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690575
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690575
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.371263 m; Start Offset: 0.371263 m; End Offset: 0.371263 m; Slope: 0
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 0.365933 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 504.235; Section: 79; Area: 0.00103978 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.0220649 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 2216
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690660
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690660
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 14.5; Insulation Thickness: 0; Invert Elevation: -0.41742 m; Additional Flow: 0; Flow: 0.0681771; Reynolds Number: 62864.3; Relative Roughness: 13716.5; Flow State: 2; Friction Factor: 0.0112912; Velocity: 6.64389; Friction: 61.6682; Pressure Drop: 117.799; Section: 125; Area: 0.0731655 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Identity Data - Mark: 2218
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 0.582233 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690761
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690761
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 2219
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 3; Insulation Thickness: 0; Invert Elevation: -0.41742 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 30815.8; Relative Roughness: 13716.5; Flow State: 2; Friction Factor: 0.0112912; Velocity: 3.25681; Friction: 14.8184; Pressure Drop: 90.7201; Section: 133; Area: 0.234492 m2
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 1.86603 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690809
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690809
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 3; Insulation Thickness: 0; Invert Elevation: -0.373013 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 30815.8; Relative Roughness: 13716.5; Flow State: 2; Friction Factor: 0.0112912; Velocity: 3.25681; Friction: 14.8184; Pressure Drop: 61.3936; Section: 133; Area: 0.158689 m2
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 1.26281 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.373013 m; Start Offset: -0.373013 m; End Offset: 0.889794 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 2221
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690837
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690837
PSet_Revit_Identity Data - Mark: 2222
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 3; Insulation Thickness: 0; Invert Elevation: 0.90907 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 3432.31; Section: 132; Area: 0.00707778 m2
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.150195 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.9144 m; Start Offset: 0.9144 m; End Offset: 0.9144 m; Slope: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690844
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690844
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Identity Data - Mark: 2223
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 10; Insulation Thickness: 0; Invert Elevation: -0.41742 m; Additional Flow: 0; Flow: 0.0601563; Reynolds Number: 55468.5; Relative Roughness: 13716.5; Flow State: 2; Friction Factor: 0.0112912; Velocity: 5.86225; Friction: 48.0116; Pressure Drop: 248.828; Section: 130; Area: 0.198508 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 1.57968 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690851
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690851
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 13; Insulation Thickness: 0; Invert Elevation: -0.41742 m; Additional Flow: 0; Flow: 0.0655035; Reynolds Number: 60399.1; Relative Roughness: 13716.5; Flow State: 2; Friction Factor: 0.0112912; Velocity: 6.38334; Friction: 56.9263; Pressure Drop: 301.523; Section: 131; Area: 0.202876 m2
PSet_Revit_Identity Data - Mark: 2224
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 1.61444 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690891
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690891
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.373013 m; Start Offset: -0.373013 m; End Offset: 0.657288 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 10; Insulation Thickness: 0; Invert Elevation: -0.373013 m; Additional Flow: 0; Flow: 0.0601563; Reynolds Number: 55468.5; Relative Roughness: 13716.5; Flow State: 2; Friction Factor: 0.0112912; Velocity: 5.86225; Friction: 48.0116; Pressure Drop: 162.291; Section: 130; Area: 0.129471 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.125; Inner Diameter: 0.114304; Size: 40 mmø; Diameter: 0.131234; Length: 1.0303 m
PSet_Revit_Identity Data - Mark: 2226
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690910
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690910
PSet_Revit_Identity Data - Mark: 2227
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 10; Insulation Thickness: 0; Invert Elevation: 0.676964 m; Additional Flow: 0; Flow: 0.0601563; Reynolds Number: 85661.5; Relative Roughness: 8881.89; Flow State: 2; Friction Factor: 0.0122545; Velocity: 13.9811; Friction: 457.719; Pressure Drop: 167.41; Section: 129; Area: 0.00875561 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.0833333; Inner Diameter: 0.0740157; Size: 25 mmø; Diameter: 0.082021; Length: 0.11148 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.688244 m; Start Offset: 0.688244 m; End Offset: 0.688244 m; Slope: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690911
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690911
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 10; Insulation Thickness: 0; Invert Elevation: 0.676964 m; Additional Flow: 0; Flow: 0.0601563; Reynolds Number: 85661.5; Relative Roughness: 8881.89; Flow State: 2; Friction Factor: 0.0122545; Velocity: 13.9811; Friction: 457.719; Pressure Drop: 318.743; Section: 129; Area: 0.0166704 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.688244 m; Start Offset: 0.688244 m; End Offset: 0.688244 m; Slope: 0
PSet_Revit_Identity Data - Mark: 2228
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.0833333; Inner Diameter: 0.0740157; Size: 25 mmø; Diameter: 0.082021; Length: 0.212254 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690933
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690933
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 2229
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.0833333; Inner Diameter: 0.0740157; Size: 25 mmø; Diameter: 0.082021; Length: 1.65377 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: -0.41128 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 8881.89; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 477; Area: 0.129887 m2
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690942
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690942
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.208333; Inner Diameter: 0.197638; Size: 65 mmø; Diameter: 0.213255; Length: 0.916343 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: -0.43012 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 23716.5; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 440; Area: 0.18712 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 2230
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690946
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690946
PSet_Revit_Dimensions - Outer Diameter: 0.0625; Inner Diameter: 0.0531824; Size: 20 mmø; Diameter: 0.0656168; Length: 0.465731 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 2231
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: -0.408105 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 66232.2; Relative Roughness: 6381.89; Flow State: 2; Friction Factor: 0.0130723; Velocity: 15.0447; Friction: 786.845; Pressure Drop: 1202.29; Section: 46; Area: 0.0292627 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:690998
In: Level 1
Type - ElementType: Pipe Types:Cold Water:690998
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: -0.40533 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 93241.2; Section: 45; Area: 0.192273 m2
PSet_Revit_Identity Data - Mark: 2232
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 4.08016 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691015
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691015
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 1.95143 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: -0.40533 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 44594.7; Section: 45; Area: 0.0919587 m2
PSet_Revit_Identity Data - Mark: 2233
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691051
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691051
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: -0.385713 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 16972.2; Section: 45; Area: 0.0349983 m2
PSet_Revit_Identity Data - Mark: 2235
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.385713 m; Start Offset: -0.385713 m; End Offset: 0.356975 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.742688 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
