Properties of the parts of a building model (IFC2X3), part 260 of 295

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:568536
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:568539
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:568539
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.2 m; Start Offset: 3.2 m; End Offset: 3.08267 m
PSet_Revit_Dimensions - Size: 250x150; Width: 0.82021; Height: 0.492126; Length: 0.117334 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.08267 m; Top Elevation: 3.2 m; Equivalent Diameter: 0.688942; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 0.615157; Section: 257; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.0938672 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1145
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:568542
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:568542
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.02231 m; Top Elevation: 3.43393 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0286743; Hydraulic Diameter: 0.984252; Section: 199; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.493948 m2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0358302; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Identity Data - Mark: 1146
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.411623 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.02231 m; Start Offset: 3.02231 m; End Offset: 3.43393 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:568547
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:568547
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.336623 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.02231 m; Top Elevation: 3.35893 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0234497; Hydraulic Diameter: 0.984252; Section: 203; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.403948 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1147
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.02231 m; Start Offset: 3.02231 m; End Offset: 3.35893 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0293017; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:568552
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:568552
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.08267 m; Top Elevation: 3.54 m; Equivalent Diameter: 0.804054; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 0.688976; Section: 263; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.457334 m2
PSet_Revit_Dimensions - Size: 350x150; Width: 1.14829; Height: 0.492126; Length: 0.457334 m
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1148
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.54 m; Start Offset: 3.54 m; End Offset: 3.08267 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:568555
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:568555
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.02231 m; Start Offset: 3.02231 m; End Offset: 3.35893 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.02231 m; Top Elevation: 3.35893 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0234497; Hydraulic Diameter: 0.984252; Section: 208; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.403948 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1149
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0293017; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.336623 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:568577
In: Level 1
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:568577
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 1; Bottom Elevation: 3.02231 m; Top Elevation: 3.53393 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0356404; Hydraulic Diameter: 0.984252; Section: 221; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.613948 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.02231 m; Start Offset: 3.02231 m; End Offset: 3.53393 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0445348; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Identity Data - Mark: 1155
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.511623 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:569086
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:569086
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.75 m; Top Elevation: 4.15 m; Equivalent Diameter: 1.94068; Size Lock: no; Loss Coefficient: 0.00520868; Hydraulic Diameter: 1.71174; Section: 34; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.420415 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.95 m; Start Offset: 3.95 m; End Offset: 3.95 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1214
PSet_Revit_Dimensions - Size: 750x400; Width: 2.46063; Height: 1.31234; Length: 0.182789 m
PSet_Revit_Mechanical - Airflow - Flow: 74.6905; Additional Flow: 0; Velocity: 23.1299; Friction: 0.0791182; Pressure Drop: 0.0474473; Velocity Pressure: 9.10929; Reynolds number: 245088
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:569090
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:569090
PSet_Revit_Identity Data - Mark: 1216
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 650x400; Width: 2.13255; Height: 1.31234; Length: 0.351236 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.75 m; Top Elevation: 4.15 m; Equivalent Diameter: 1.81547; Size Lock: no; Loss Coefficient: 0.0108943; Hydraulic Diameter: 1.6248; Section: 32; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.737595 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 58.0926; Additional Flow: 0; Velocity: 20.7576; Friction: 0.0693595; Pressure Drop: 0.0799264; Velocity Pressure: 7.33654; Reynolds number: 208779
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.95 m; Start Offset: 3.95 m; End Offset: 3.95 m; Slope: 0
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:569092
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:569092
PSet_Revit_Dimensions - Size: 550x400; Width: 1.80446; Height: 1.31234; Length: 0.6015 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.75 m; Top Elevation: 4.15 m; Equivalent Diameter: 1.67692; Size Lock: no; Loss Coefficient: 0.0195459; Hydraulic Diameter: 1.51955; Section: 31; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.14285 m2
PSet_Revit_Identity Data - Mark: 1217
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.95 m; Start Offset: 3.95 m; End Offset: 3.95 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 58.0926; Additional Flow: 0; Velocity: 24.5317; Friction: 0.101491; Pressure Drop: 0.200285; Velocity Pressure: 10.2469; Reynolds number: 230755
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:569094
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:569094
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1218
PSet_Revit_Mechanical - Airflow - Flow: 41.4947; Additional Flow: 0; Velocity: 17.5227; Friction: 0.0554798; Pressure Drop: 0.0424168; Velocity Pressure: 5.22801; Reynolds number: 164825
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.75 m; Top Elevation: 4.15 m; Equivalent Diameter: 1.67692; Size Lock: no; Loss Coefficient: 0.00811337; Hydraulic Diameter: 1.51955; Section: 29; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.442763 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.95 m; Start Offset: 3.95 m; End Offset: 3.95 m; Slope: 0
PSet_Revit_Dimensions - Size: 550x400; Width: 1.80446; Height: 1.31234; Length: 0.233033 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:569096
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:569096
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.75 m; Top Elevation: 4.15 m; Equivalent Diameter: 1.4346; Size Lock: no; Loss Coefficient: 0.0220016; Hydraulic Diameter: 1.31234; Section: 27; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.864 m2
PSet_Revit_Identity Data - Mark: 1219
PSet_Revit_Dimensions - Size: 400x400; Width: 1.31234; Height: 1.31234; Length: 0.54 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.95 m; Start Offset: 3.95 m; End Offset: 3.95 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 33.1958; Additional Flow: 0; Velocity: 19.2749; Friction: 0.0785592; Pressure Drop: 0.13918; Velocity Pressure: 6.32589; Reynolds number: 156584
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:569098
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:569098
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.775 m; Top Elevation: 4.125 m; Equivalent Diameter: 1.3412; Size Lock: no; Loss Coefficient: 0.344521; Hydraulic Diameter: 1.22485; Section: 26; Insulation Thickness: 0; Lining Thickness: 0; Area: 11.9972 m2
PSet_Revit_Identity Data - Mark: 1220
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.95 m; Start Offset: 3.95 m; End Offset: 3.95 m; Slope: 0
PSet_Revit_Dimensions - Size: 400x350; Width: 1.31234; Height: 1.14829; Length: 7.99813 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 33.1958; Additional Flow: 0; Velocity: 22.0285; Friction: 0.10848; Pressure Drop: 2.84657; Velocity Pressure: 8.26239; Reynolds number: 167023
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:569100
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:569100
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.775 m; Top Elevation: 4.125 m; Equivalent Diameter: 1.3412; Size Lock: no; Loss Coefficient: 0.0116965; Hydraulic Diameter: 1.22485; Section: 24; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.3525 m2
PSet_Revit_Mechanical - Airflow - Flow: 16.5979; Additional Flow: 0; Velocity: 11.0142; Friction: 0.0313363; Pressure Drop: 0.0241602; Velocity Pressure: 2.0656; Reynolds number: 83511.4
PSet_Revit_Dimensions - Size: 400x350; Width: 1.31234; Height: 1.14829; Length: 0.235 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.95 m; Start Offset: 3.95 m; End Offset: 3.95 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1221
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:569102
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:569102
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 9.63747; Friction: 0.0377765; Pressure Drop: 0.0396604; Velocity Pressure: 1.58147; Reynolds number: 52194.6
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.95 m; Start Offset: 3.95 m; End Offset: 3.95 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1222
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 400x200; Width: 1.31234; Height: 0.656168; Length: 0.32 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.85 m; Top Elevation: 4.05 m; Equivalent Diameter: 0.99959; Size Lock: no; Loss Coefficient: 0.0250781; Hydraulic Diameter: 0.874891; Section: 22; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.384 m2
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:569104
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:569104
PSet_Revit_Identity Data - Mark: 1223
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.95 m; Start Offset: 3.95 m; End Offset: 3.95 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 12.85; Friction: 0.080316; Pressure Drop: 0.728495; Velocity Pressure: 2.81151; Reynolds number: 56939.6
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.875 m; Top Elevation: 4.025 m; Equivalent Diameter: 0.853458; Size Lock: no; Loss Coefficient: 0.259112; Hydraulic Diameter: 0.71582; Section: 21; Insulation Thickness: 0; Lining Thickness: 0; Area: 3.04111 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 400x150; Width: 1.31234; Height: 0.492126; Length: 2.76464 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:569106
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:569106
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.875 m; Top Elevation: 4.025 m; Equivalent Diameter: 0.853458; Size Lock: no; Loss Coefficient: 0.160878; Hydraulic Diameter: 0.71582; Section: 21; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.88817 m2
PSet_Revit_Dimensions - Size: 400x150; Width: 1.31234; Height: 0.492126; Length: 1.71652 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 12.85; Friction: 0.080316; Pressure Drop: 0.452309; Velocity Pressure: 2.81151; Reynolds number: 56939.6
PSet_Revit_Identity Data - Mark: 1224
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.95 m; Start Offset: 3.95 m; End Offset: 3.95 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:569107
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:569107
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0667934; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Identity Data - Mark: 1225
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.767334 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 2.9016 m; Top Elevation: 3.66893 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0534536; Hydraulic Diameter: 0.984252; Section: 20; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.920801 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.9016 m; Start Offset: 2.9016 m; End Offset: 3.66893 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:569111
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:569111
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.875 m; Top Elevation: 4.025 m; Equivalent Diameter: 0.853458; Size Lock: no; Loss Coefficient: 0.155221; Hydraulic Diameter: 0.71582; Section: 39; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.82178 m2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 12.85; Friction: 0.080316; Pressure Drop: 0.436405; Velocity Pressure: 2.81151; Reynolds number: 56939.6
PSet_Revit_Dimensions - Size: 400x150; Width: 1.31234; Height: 0.492126; Length: 1.65616 m
PSet_Revit_Identity Data - Mark: 1226
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.95 m; Start Offset: 3.95 m; End Offset: 3.95 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:569112
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:569112
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 2.9016 m; Top Elevation: 3.66893 m; Equivalent Diameter: 1.07595; Size Lock: no; Loss Coefficient: 0.0534536; Hydraulic Diameter: 0.984252; Section: 38; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.920801 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 8.56664; Friction: 0.0265316; Pressure Drop: 0.0667934; Velocity Pressure: 1.24956; Reynolds number: 52194.6
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.9016 m; Start Offset: 2.9016 m; End Offset: 3.66893 m
PSet_Revit_Dimensions - Size: 300x300; Width: 0.984252; Height: 0.984252; Length: 0.767334 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1227
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:569114
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:569114
PSet_Revit_Identity Data - Mark: 1228
PSet_Revit_Dimensions - Size: 400x200; Width: 1.31234; Height: 0.656168; Length: 1.94893 m
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.85 m; Top Elevation: 4.05 m; Equivalent Diameter: 0.99959; Size Lock: no; Loss Coefficient: 0.129634; Hydraulic Diameter: 0.874891; Section: 23; Insulation Thickness: 0; Lining Thickness: 0; Area: 2.33872 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.95 m; Start Offset: 3.95 m; End Offset: 3.95 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 16.5979; Additional Flow: 0; Velocity: 19.2749; Friction: 0.12825; Pressure Drop: 0.82005; Velocity Pressure: 6.32589; Reynolds number: 104389
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Rectangular Elbow - Mitered: Rectangular Elbow - Mitered; Preferred Junction Type: 1; Tee: M_Rectangular Tee: Rectangular Tee; Tap: M_Rectangular Takeoff: Rectangular Takeoff; Cross: M_Rectangular Cross: Rectangular Cross; Transition: M_Rectangular Transition - Angle: Rectangular Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Union: M_Rectangular Union: Rectangular Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer

# IfcFlowSegment: Rectangular Duct:Mitered Elbows / Tees:569118
In: Level 2
Type - ElementType: Rectangular Duct:Mitered Elbows / Tees:569118
PSet_Revit_Identity Data - Mark: 1229
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 350x150; Width: 1.14829; Height: 0.492126; Length: 1.0151 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 14.6857; Friction: 0.106423; Pressure Drop: 0.354429; Velocity Pressure: 3.67217; Reynolds number: 62633.6
PSet_Revit_Mechanical - System Type: Return Air; System Name: Mechanical Return Air 2; Bottom Elevation: 3.875 m; Top Elevation: 4.025 m; Equivalent Diameter: 0.804054; Size Lock: no; Loss Coefficient: 0.0965175; Hydraulic Diameter: 0.688976; Section: 43; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.0151 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.95 m; Start Offset: 3.95 m; End Offset: 3.95 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
