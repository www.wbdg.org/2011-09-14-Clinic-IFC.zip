Properties of the parts of a building model (IFC2X3), part 21 of 295

# IfcFlowFitting: Elbow - Generic (2063)
Name (M_Elbow - Generic:Elbow - Generic:Elbow - Generic:...) | In | Level | Host | Offset (m) | Mark | Tick Size | Nominal Radius | Nominal Diameter | Insulation Radius = Fitting Outside Radius | Fitting Outside Diameter | Center to End | Angle (deg) | Size | Center Radius | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | System Type | System Name
1051522 | 2A11 | Level 2 | Level : Level 2 | 2.985 | 12919 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
695260 | 1CC1 | Level 2 | Level : Level 2 | -1.5 | 6793 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
698965 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 7250 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
712226 | Level 2 | Level 2 | Level : Level 2 | 0.3 | 8844 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1026439 | 1EC1 | Level 1 | Level : Level 1 | 2.985 | 11083 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
644764 | Level 1 | Level 1 | Level : Level 1 | 3 | 2854 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
689601 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 6190 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
712200 | 2B6 | Level 2 | Level : Level 2 | 0.3 | 8836 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1063013 | 2D05 | Level 2 | Level : Level 2 | 2.985 | 13515 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
702232 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7596 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
708472 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8383 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1004966 | 1E24 | Level 1 | Level : Level 1 | 2.985 | 10339 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
688139 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 6012 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
633647 | Level 1 | Level 1 | Level : Level 1 | 0.232932 | 1452 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1063309 | 2D05 | Level 1 | Level : Level 1 | 7.555 | 13522 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
689292 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 6166 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
707055 | 1C12 | Level 1 | Level : Level 1 | 0.2 | 8159 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1079986 | Level 1 | Level 1 | Level : Level 1 | 0.806263 | 14150 | 0.020779 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.0467529 | 89.8505 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
660352 | 1DC4 | Level 2 | Level : Level 2 | -1.6882 | 3909 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
722240 | 2D05 | Level 2 | Level : Level 2 | 4.236 | 9632 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Storm
1077944 | 1D10 | Level 1 | Level : Level 1 | 0.2 | 13988 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1063300 | 2D05 | Level 1 | Level : Level 1 | 7.555 | 13519 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
705090 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 7948 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
705525 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 8007 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1078312 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 14026 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
683526 | Level 1 | Level 1 | Level : Level 1 | 0.232932 | 5419 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
641200 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 2430 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
644346 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 2825 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
639162 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 2168 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1078077 | 1D10 | Level 1 | Level : Level 1 | 0.806263 | 14012 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1026475 | 1EC1 | Level 1 | Level : Level 1 | 2.985 | 11091 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
663685 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 4327 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
680754 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5179 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1026743 | 1DC8 | Level 1 | Level : Level 1 | 2.985 | 11171 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
687042 | 1D05 | Level 1 | Level : Level 1 | 0.806263 | 5877 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
697686 | 1D12 | Level 2 | Level : Level 2 | -1.5 | 7079 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1073769 | 1C06 | Level 2 | Level : Level 2 | -0.905 | 13789 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Undefined
698927 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 7241 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1013789 | 1CC1 | Level 1 | Level : Level 1 | 2.985 | 10910 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
721639 | 1E24 | Level 2 | Level : Level 2 | -0.444 | 9584 | 0.0845686 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.11434 | 45 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Undefined
678882 | Level 1 | Level 1 | Level : Level 1 | 0.5 | 4972 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
714932 | Level 2 | Level 2 | Level : Level 2 | 0.3 | 9093 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
640411 | Level 1 | Level 1 | Level : Level 1 | 0.232932 | 2363 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
719714 | 1DC3 | Level 2 | Level : Level 2 | -1.4 | 9537 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1027246 | 1BC2 | Level 1 | Level : Level 1 | 2.985 | 11347 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
687043 | Level 1 | Level 1 | Level : Level 1 | 0.806263 | 5878 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
701808 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 7550 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
641808 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 2499 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1070465 | 2D05 | Level 2 | Level : Level 2 | 4 | 13737 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Return | Hydronic Return 1
706801 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8129 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1080858 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 14222 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
701147 | Level 1 | Level 1 | Level : Level 1 | 0.688244 | 7487 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
701505 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 7516 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
648502 | 1D07 | Level 1 | Level : Level 1 | 2.8 | 3279 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1049925 | 2D15 | Level 2 | Level : Level 2 | 2.985 | 12471 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1077348 | 1D07 | Level 1 | Level : Level 1 | 0.2 | 13939 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
714736 | 1DC3 | Level 2 | Level : Level 2 | -1.4 | 9080 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1077529 | 1D02 | Level 1 | Level : Level 1 | 0.635088 | 13954 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
696254 | Level 2 | Level 2 | Level : Level 2 | 0.688244 | 6898 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1070444 | 2D05 | Level 2 | Level : Level 2 | 3.8 | 13730 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Supply | Hydronic Supply 1
1052925 | 2D18 | Level 2 | Level : Level 2 | 2.985 | 13253 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
711171 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8716 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
640092 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2330 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
680650 | 1B19 | Level 1 | Level : Level 1 | 0.371263 | 5167 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
707819 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8280 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
695392 | 1D04 | Level 2 | Level : Level 2 | -1.5 | 6816 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
694228 | Level 2 | Level 2 | Level : Level 2 | 0.806263 | 6686 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
704403 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7887 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1080034 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 14154 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
711025 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8688 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1118046 | 2C10 | Level 2 | Level : Level 2 | 0.860313 | 15123 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1013220 | 1D18 | Level 1 | Level : Level 1 | 2.985 | 10734 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
681860 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 5292 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1052788 | 2CC2 | Level 2 | Level : Level 2 | 2.985 | 13209 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
680119 | Level 1 | Level 1 | Level : Level 1 | 0.371263 | 5105 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1013444 | 1C10 | Level 1 | Level : Level 1 | 2.985 | 10818 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
701429 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7511 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1049072 | 2DC2 | Level 2 | Level : Level 2 | 2.985 | 12223 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
709143 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8478 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1028007 | 1DC7 | Level 1 | Level : Level 1 | 2.985 | 11583 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1062706 | 1AC2 | Level 1 | Level : Level 1 | 2.985 | 13478 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
682726 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5380 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1085911 | Level 2 | Level 2 | Level : Level 2 | 0.5 | 14668 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
706702 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8117 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
714660 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 9073 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
698399 | 1D08 | Level 2 | Level : Level 2 | -1.56 | 7148 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
655122 | 1B05 | Level 1 | Level : Level 1 | 0 | 3401 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
634487 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1588 | 0.0344524 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0531986 | 51.8754 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
1082049 | 1CC1 | Level 2 | Level : Level 2 | -1.5 | 14313 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
698985 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 7258 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1114244 | 2A10 | Level 2 | Level : Level 2 | 2.985 | 15097 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1028527 | 1AC2 | Level 1 | Level : Level 1 | 2.90444 | 11648 | 0.00862945 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.0194163 | 45 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
711246 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8729 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
637263 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 1996 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
708274 | 1A13 | Level 1 | Level : Level 1 | 0.688244 | 8360 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
658096 | Level 1 | Level 2 | Level : Level 2 | -1.6882 | 3659 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1082911 | 2A07 | Level 2 | Level : Level 2 | 0.2 | 14400 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
713922 | Level 1 | Level 2 | Level : Level 2 | -1.35 | 9012 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
704264 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 7880 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
711612 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8764 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
647784 | Level 1 | Level 1 | Level : Level 1 | 1 | 3231 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
702849 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7696 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
698593 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 7186 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
698969 | Level 2 | Level 2 | Level : Level 2 | 0.688244 | 7254 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
712609 | 1B03 | Level 2 | Level : Level 2 | -1.35 | 8852 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
694827 | 1CC1 | Level 2 | Level : Level 2 | -1.5 | 6740 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
682307 | 1C12 | Level 1 | Level : Level 1 | 0.371263 | 5350 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
692955 | Level 2 | Level 2 | Level : Level 2 | 0.688244 | 6570 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
654457 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 3356 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
684807 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5599 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
643291 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2709 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
1004989 | 1E16 | Level 1 | Level : Level 1 | 2.985 | 10347 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
707057 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8161 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1073700 | 1E24 | Level 2 | Level : Level 2 | -0.905 | 13777 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Undefined
643198 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2696 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
1077151 | 1D09 | Level 1 | Level : Level 1 | 0.635088 | 13914 | 0.0458334 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.0781251 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
701889 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7559 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
643493 | 1B19 | Level 1 | Level : Level 1 | 2.9 | 2733 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
633873 | 1E09 | Level 1 | Level : Level 1 | 0.1 | 1480 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
705038 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 7942 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
714952 | Level 2 | Level 2 | Level : Level 2 | 0.3 | 9095 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1079220 | 1D36 | Level 1 | Level : Level 1 | 0.3 | 14100 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
635192 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 1726 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
704207 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7871 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1073557 | Level 2 | Level 2 | Level : Level 2 | 4.162 | 13766 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
643196 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2694 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
633850 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1477 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
685260 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 5668 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1067052 | TOF Footing | Level 1 | Level : Level 1 | -0.6 | 13533 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Return | Hydronic Return 1
702280 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 7598 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
700140 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7383 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
660433 | 1DC4 | Level 2 | Level : Level 2 | -1.6882 | 3918 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
693263 | 1E33 | Level 2 | Level : Level 2 | -1.5 | 6607 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
708796 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8434 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
661125 | 2C16 | Level 2 | Level : Level 2 | 0.5 | 4017 | 0.0293401 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0453046 | 45 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1114236 | 2A10 | Level 2 | Level : Level 2 | 2.985 | 15095 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
710317 | 1D12 | Level 1 | Level : Level 1 | 0.2 | 8602 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
638190 | Level 1 | Level 1 | Level : Level 1 | 0.232932 | 2122 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1047765 | 2C17 | Level 2 | Level : Level 2 | 2.985 | 11955 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1082022 | 2C06 | Level 2 | Level : Level 2 | 0.2 | 14307 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1049961 | 2D19 | Level 2 | Level : Level 2 | 2.985 | 12479 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
695478 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 6838 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
689029 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 6132 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
665885 | 1D02 | Level 2 | Level : Level 2 | -1.6882 | 4567 | 0.0293401 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0453046 | 45 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1026533 | 1E04 | Level 1 | Level : Level 1 | 2.985 | 11103 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
633882 | Level 1 | Level 1 | Level : Level 1 | 0.1 | 1482 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
705620 | 1B11 | Level 1 | Level : Level 1 | 0.2 | 8028 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1082819 | 2A08 | Level 2 | Level : Level 2 | 0.2 | 14384 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
636676 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1926 | 0.0293749 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0453582 | 45.0479 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
637744 | Level 1 | Level 1 | Level : Level 1 | 0.55 | 2077 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
643566 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2740 | 0.0293401 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0453046 | 45 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
659116 | 1D13 | Level 2 | Level : Level 2 | -1.4 | 3777 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
682616 | 1E11 | Level 1 | Level : Level 1 | 0.806263 | 5368 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1027507 | 1D02 | Level 1 | Level : Level 1 | 2.985 | 11411 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1077173 | 1D07 | Level 1 | Level : Level 1 | 0.635088 | 13920 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
643343 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2712 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
1063005 | 2D05 | Level 1 | Level : Level 1 | 7.555 | 13513 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
719715 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 9538 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
708551 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8396 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
715189 | TOF Footing | Level 1 | Level : Level 1 | -0.25 | 9110 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
678880 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 4970 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
640625 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2401 | 0.0285575 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0440961 | 43.9151 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
723155 | 2D05 | Level 2 | Level : Level 2 | 3.775 | 9684 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Storm
693060 | 1BC2 | Level 2 | Level : Level 2 | -1.5 | 6593 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
661481 | 1CC1 | Level 2 | Level : Level 2 | -1.6882 | 4058 | 0.0293401 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0453046 | 45 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1026853 | 1E03 | Level 1 | Level : Level 1 | 2.985 | 11195 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1026682 | 1D35 | Level 1 | Level : Level 1 | 2.985 | 11151 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1078496 | 1D35 | Level 1 | Level : Level 1 | 0.806263 | 14041 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
637500 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 2026 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
701947 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 7572 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
647517 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 3199 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
707368 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8227 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
641110 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 2414 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
692848 | 1B04 | Level 2 | Level : Level 2 | -1.5 | 6556 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
665301 | Level 2 | Level 2 | Level : Level 2 | 3.1 | 4536 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
692593 | 1B03 | Level 2 | Level : Level 2 | -1.5 | 6525 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1004875 | 1E24 | Level 1 | Level : Level 1 | 2.985 | 10327 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
711333 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8750 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
700886 | 1E10 | Level 1 | Level : Level 1 | 0.3 | 7448 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
710308 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8599 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
698989 | Level 2 | Level 2 | Level : Level 2 | 0.688244 | 7262 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
637209 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 1989 | 0.0569592 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798292 | 45.0035 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
678300 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 4940 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
683636 | Level 1 | Level 1 | Level : Level 1 | 0.688244 | 5451 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
708489 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8388 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
662309 | Level 1 | Level 2 | Level : Level 2 | -1.6882 | 4189 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1081976 | 2C06 | Level 2 | Level : Level 2 | 0.2 | 14300 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1077506 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 13948 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
710450 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8620 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
710541 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8634 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
643604 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 2749 | 0.0224366 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0366752 | 45 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
640566 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2390 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
694223 | Level 2 | Level 2 | Level : Level 2 | 0.806263 | 6681 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
684993 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5636 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
718886 | 1A16 | Level 2 | Level : Level 2 | -1.4 | 9457 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
637642 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 2057 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
639880 | TOF Footing | Level 1 | Level : Level 1 | -0.2 | 2291 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1078078 | Level 1 | Level 1 | Level : Level 1 | 0.806263 | 14013 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1080598 | 1B10 | Level 1 | Level : Level 1 | 0.371263 | 14202 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
635096 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1699 | 0.0708036 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109329 | 89.9759 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
701795 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 7545 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
644960 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 2884 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
