Properties of the parts of a building model (IFC2X3), part 289 of 295

# IfcFlowSegment: Round Duct:Taps:567311
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1.5 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union

# IfcFlowSegment: Round Duct:Taps:567315
In: Level 1
Type - ElementType: Round Duct:Taps:567315
PSet_Revit_Dimensions - Size: 150ø; Diameter: 0.492126; Length: 1.64478 m
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 43.6295; Friction: 1.11053; Pressure Drop: 5.99272; Velocity Pressure: 32.4113; Reynolds number: 132913
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.425 m; Top Elevation: 3.575 m; Size Lock: no; Loss Coefficient: 0.184896; Hydraulic Diameter: 0.492126; Section: 431; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.775087 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.5 m; Start Offset: 3.5 m; End Offset: 3.5 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 296
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1.5 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union

# IfcFlowSegment: Round Duct:Taps:567317
In: Level 1
Type - ElementType: Round Duct:Taps:567317
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 297
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 350ø; Diameter: 1.14829; Length: 1.86919 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.615 m; Top Elevation: 3.965 m; Size Lock: no; Loss Coefficient: 0.0949917; Hydraulic Diameter: 1.14829; Section: 414; Insulation Thickness: 0; Lining Thickness: 0; Area: 2.05528 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.79 m; Start Offset: 3.79 m; End Offset: 3.79 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 14.4927; Friction: 0.0553961; Pressure Drop: 0.339717; Velocity Pressure: 3.57628; Reynolds number: 103017
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1.5 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union

# IfcFlowSegment: Round Duct:Taps:567325
In: Level 1
Type - ElementType: Round Duct:Taps:567325
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.665 m; Top Elevation: 3.915 m; Size Lock: no; Loss Coefficient: 0.0314397; Hydraulic Diameter: 0.82021; Section: 405; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.328411 m2
PSet_Revit_Identity Data - Mark: 307
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.418145 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.0962648; Pressure Drop: 0.132063; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.79 m; Start Offset: 3.79 m; End Offset: 3.79 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1.5 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union

# IfcFlowSegment: Round Duct:Taps:567327
In: Level 1
Type - ElementType: Round Duct:Taps:567327
PSet_Revit_Identity Data - Mark: 309
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.665 m; Top Elevation: 3.915 m; Size Lock: no; Loss Coefficient: 0.292612; Hydraulic Diameter: 0.82021; Section: 407; Insulation Thickness: 0; Lining Thickness: 0; Area: 3.05655 m2
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 3.89171 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.79 m; Start Offset: 3.79 m; End Offset: 3.79 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.0962648; Pressure Drop: 1.22912; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1.5 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union

# IfcFlowSegment: Round Duct:Taps:567329
In: Level 1
Type - ElementType: Round Duct:Taps:567329
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.79 m; Start Offset: 3.79 m; End Offset: 3.79 m; Slope: 0
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 0.343145 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.665 m; Top Elevation: 3.915 m; Size Lock: no; Loss Coefficient: 0.0258005; Hydraulic Diameter: 0.82021; Section: 411; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.269506 m2
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.0962648; Pressure Drop: 0.108375; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 311
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1.5 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union

# IfcFlowSegment: Round Duct:Taps:567331
In: Level 1
Type - ElementType: Round Duct:Taps:567331
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.665 m; Top Elevation: 3.915 m; Size Lock: no; Loss Coefficient: 0.286973; Hydraulic Diameter: 0.82021; Section: 416; Insulation Thickness: 0; Lining Thickness: 0; Area: 2.99764 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.79 m; Start Offset: 3.79 m; End Offset: 3.79 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 8.29895; Additional Flow: 0; Velocity: 15.7066; Friction: 0.0962648; Pressure Drop: 1.20543; Velocity Pressure: 4.20051; Reynolds number: 79747.5
PSet_Revit_Dimensions - Size: 250ø; Diameter: 0.82021; Length: 3.81671 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 313
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1.5 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union

# IfcFlowSegment: Round Duct:Taps:567333
In: Level 1
Type - ElementType: Round Duct:Taps:567333
PSet_Revit_Dimensions - Size: 400ø; Diameter: 1.31234; Length: 1.0824 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.79 m; Start Offset: 3.79 m; End Offset: 3.79 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.59 m; Top Elevation: 3.99 m; Size Lock: no; Loss Coefficient: 0.0356179; Hydraulic Diameter: 1.31234; Section: 292; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.36018 m2
PSet_Revit_Mechanical - Airflow - Flow: 75.0437; Additional Flow: 0; Velocity: 55.4797; Friction: 0.525653; Pressure Drop: 1.86669; Velocity Pressure: 52.4088; Reynolds number: 450701
PSet_Revit_Identity Data - Mark: 315
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1.5 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union

# IfcFlowSegment: Round Duct:Taps:567335
In: Level 1
Type - ElementType: Round Duct:Taps:567335
PSet_Revit_Mechanical - Airflow - Flow: 75.0437; Additional Flow: 0; Velocity: 55.4797; Friction: 0.525653; Pressure Drop: 1.75451; Velocity Pressure: 52.4088; Reynolds number: 450701
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.79 m; Start Offset: 3.79 m; End Offset: 3.79 m; Slope: 0
PSet_Revit_Dimensions - Size: 400ø; Diameter: 1.31234; Length: 1.01736 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.59 m; Top Elevation: 3.99 m; Size Lock: no; Loss Coefficient: 0.0334775; Hydraulic Diameter: 1.31234; Section: 292; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.27845 m2
PSet_Revit_Identity Data - Mark: 316
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1.5 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union

# IfcFlowSegment: Round Duct:Taps:567337
In: Level 1
Type - ElementType: Round Duct:Taps:567337
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.79 m; Start Offset: 3.79 m; End Offset: 3.79 m; Slope: 0
PSet_Revit_Dimensions - Size: 350ø; Diameter: 1.14829; Length: 4.33066 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.615 m; Top Elevation: 3.965 m; Size Lock: no; Loss Coefficient: 0.165769; Hydraulic Diameter: 1.14829; Section: 290; Insulation Thickness: 0; Lining Thickness: 0; Area: 4.76181 m2
PSet_Revit_Identity Data - Mark: 317
PSet_Revit_Mechanical - Airflow - Flow: 60.0349; Additional Flow: 0; Velocity: 57.9706; Friction: 0.667601; Pressure Drop: 9.48542; Velocity Pressure: 57.2206; Reynolds number: 412069
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1.5 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union

# IfcFlowSegment: Round Duct:Taps:567339
In: Level 1
Type - ElementType: Round Duct:Taps:567339
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.79 m; Start Offset: 3.79 m; End Offset: 3.79 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 44.3838; Friction: 0.809201; Pressure Drop: 1.3777; Velocity Pressure: 33.5416; Reynolds number: 180280
PSet_Revit_Dimensions - Size: 200ø; Diameter: 0.656168; Length: 0.518935 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.69 m; Top Elevation: 3.89 m; Size Lock: no; Loss Coefficient: 0.0410743; Hydraulic Diameter: 0.656168; Section: 288; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.326056 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 318
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1.5 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union

# IfcFlowSegment: Round Duct:Taps:567723
In: Level 1
Type - ElementType: Round Duct:Taps:567723
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Size: 350ø; Diameter: 1.14829; Length: 0.316953 m
PSet_Revit_Mechanical - Airflow - Flow: 60.0349; Additional Flow: 0; Velocity: 57.9706; Friction: 0.667601; Pressure Drop: 0.69422; Velocity Pressure: 57.2206; Reynolds number: 412069
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.69 m; Start Offset: 3.69 m; End Offset: 3.69 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.515 m; Top Elevation: 3.865 m; Size Lock: no; Loss Coefficient: 0.0121323; Hydraulic Diameter: 1.14829; Section: 265; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.348508 m2
PSet_Revit_Identity Data - Mark: 581
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1.5 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union

# IfcFlowSegment: Round Duct:Taps:567725
In: Level 1
Type - ElementType: Round Duct:Taps:567725
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.125 m; Top Elevation: 3.475 m; Size Lock: no; Loss Coefficient: 0.0197063; Hydraulic Diameter: 1.14829; Section: 265; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.566075 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.3 m; Start Offset: 3.3 m; End Offset: 3.3 m; Slope: 0
PSet_Revit_Identity Data - Mark: 583
PSet_Revit_Mechanical - Airflow - Flow: 60.0349; Additional Flow: 0; Velocity: 57.9706; Friction: 0.667601; Pressure Drop: 1.12761; Velocity Pressure: 57.2206; Reynolds number: 412069
PSet_Revit_Dimensions - Size: 350ø; Diameter: 1.14829; Length: 0.514821 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1.5 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union

# IfcFlowSegment: Round Duct:Taps:567726
In: Level 1
Type - ElementType: Round Duct:Taps:567726
PSet_Revit_Dimensions - Size: 300ø; Diameter: 0.984252; Length: 1.1103 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.3 m; Start Offset: 3.3 m; End Offset: 3.3 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.15 m; Top Elevation: 3.45 m; Size Lock: no; Loss Coefficient: 0.0637321; Hydraulic Diameter: 0.984252; Section: 555; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.04643 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 19.7261; Friction: 0.115919; Pressure Drop: 0.422258; Velocity Pressure: 6.62551; Reynolds number: 120187
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 585
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1.5 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union

# IfcFlowSegment: Round Duct:Taps:570710
In: Level 1
Type - ElementType: Round Duct:Taps:570710
PSet_Revit_Mechanical - Airflow - Flow: 60.0349; Additional Flow: 0; Velocity: 57.9706; Friction: 0.667601; Pressure Drop: 0.0847462; Velocity Pressure: 57.2206; Reynolds number: 412069
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.69 m; Start Offset: 3.69 m; End Offset: 3.69 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 360
PSet_Revit_Dimensions - Size: 350ø; Diameter: 1.14829; Length: 0.0386917 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.515 m; Top Elevation: 3.865 m; Size Lock: no; Loss Coefficient: 0.00148105; Hydraulic Diameter: 1.14829; Section: 265; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.0425438 m2
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1.5 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union

# IfcFlowSegment: Round Duct:Taps:570711
In: Level 1
Type - ElementType: Round Duct:Taps:570711
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 350ø; Diameter: 1.14829; Length: 0.498653 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.37034 m; Start Offset: 3.37034 m; End Offset: 3.61966 m; Slope: 0.577349
PSet_Revit_Mechanical - Airflow - Flow: 60.0349; Additional Flow: 0; Velocity: 57.9706; Friction: 0.667601; Pressure Drop: 1.0922; Velocity Pressure: 57.2206; Reynolds number: 412069
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.21878 m; Top Elevation: 3.77122 m; Size Lock: no; Loss Coefficient: 0.0190875; Hydraulic Diameter: 1.14829; Section: 265; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.548298 m2
PSet_Revit_Identity Data - Mark: 361
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Construction - Roughness: 0
PSet_Revit_Type_Fitting - Elbow: M_Round Elbow: Round Elbow - 1.5 D; Preferred Junction Type: 0; Tee: M_Round Tee: Round Tee; Tap: M_Round Takeoff: Round Takeoff; Cross: M_Round Cross: Round Cross; Transition: M_Round Transition - Angle: Round Transition - 45 Degree; Multi Shape Transition Rect to Round: M_Rectangular to Round Transition - Angle: Rectangular to Round Transition - 45 Degree; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Round Union: Round Union

# IfcFlowStorageDevice: 380 L, M_Water Heater:380 L:380 L:1061086
In: 2D05
Type - ElementType: 380 L; PredefinedType: PREFORMED
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Electrical - Loads - Panel: MS2; Circuit Number: 6
PSet_Revit_Mechanical - System Type: Domestic Cold Water,Domestic Hot Water,Sanitary,Exhaust Air,Power; System Name: Domestic Cold Water 1,Domestic Hot Water 1,Sanitary 1,Mechanical Exhaust Air 1
PSet_Revit_Identity Data - Mark: W.H.
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.65.35.11.11; OmniClass Title: Storage Water Heaters
PSet_Revit_Constraints - Level: Level 2; Host: Level : Level 2; Offset: 0 m
PSet_Revit_Other - TagNumber: W.H.; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Electrical - Loads - Apparent Load: 48437.6
PSet_Revit_Type_Dimensions - Water Heater Radius: 0.337 m; Water Heater Height: 1.696 m; Sanitary Radius: 0.0246063; Sanitary Diameter: 0.0492126; Vent Radius: 0.164042; Vent Diameter: 0.328084; Hot Water Radius: 0.0524934; Hot Water Diameter: 0.104987; Cold Water Radius: 0.0524934; Cold Water Diameter: 0.104987
PSet_Revit_Type_Electrical - Voltage: 2238.89; Number of Poles: 2; Load Classification: Appliance - Dwelling Unit

# IfcFlowTerminal: 0600x0600mm(2 Lamp) - 120V (159)
Type - ElementType: 0600x0600mm(2 Lamp) - 120V
PSet_Revit_Constraints - Elevation: 2.68 m
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Electrical - Circuiting - Electrical Data: 120 V/1-40 VA
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Electrical - Lighting - Calculate Coefficient of Utilization: no
PSet_Revit_Type_Photometrics - Light Source Definition (family): Point+HemiSpherical; Light Loss Factor: 0; Initial Intensity: 0; Initial Color: 0; Dimming Lamp Color Temperature Shift: 0; Color Filter: 16777215
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.80.70.11.14.11; OmniClass Title: Downlights
PSet_Revit_Type_Electrical - Load Classification: Lighting - Dwelling Unit; Lamp: T-12; Ballast Voltage: 1291.67; Ballast Number of Poles: 1
PSet_Revit_Type_Electrical - Loads - Apparent Load: 430.556
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Dimensions - Light Source Symbol Size: 0.05 m
PSet_Revit_Type_Materials and Finishes - Light Box Material: Metal - Chrome; Grid Material: Metal - Paint Finish - Dark Gray, Matte; Diffuser Material: Glass - White, High Luminance
PSet_Revit_Type_Constraints - Default Elevation: 1.2 m
Name (M_Troffer Light - Parabolic Square:0600x0600mm(2 Lamp) - 120V:0600x0600mm(2 Lamp) - 120V:...) | In | Host | Schedule Level | TagNumber = Mark | Panel | Circuit Number
746231 | 1E12 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 3
810474 | 1D14 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 3
990974 | 1A13 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | N21C1 | 24
809583 | 1CC2 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 2
817488 | 1DC8 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41B | 4
756022 | 2A01 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 6
817515 | 1D39 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 4
743013 | 1AC3 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 2
756541 | 2CC5 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42C | 3
756519 | 2CC4 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42C | 3
756551 | 2CC1 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 3
743001 | 1AC2 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41C | 2
827061 | 1B19 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3D | L41B | 1
756529 | 2CC5 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 3
756511 | 2CC3 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 3
743039 | 1CC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41C | 2
742765 | 1AC2 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 2
756597 | 2DC2 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 4
756647 | 2DC1 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 4
756563 | 2CC1 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42C | 3
743047 | 1CC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 2
743206 | 1CC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 2
743101 | 1CC3 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41C | 2
743109 | 1C12 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 4
756270 | 2A01 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 6
743093 | 1CC3 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 2
827067 | 1B19 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3D | L41B | 1
756589 | 2DC2 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 4
756475 | 2CC2 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 3
756757 | 2BC4 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 4
756287 | 2A01 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 6
743218 | 1DC4 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 2
743885 | 1AC5 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 1
743772 | 1B19 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3D | L41B | 1
756467 | 2CC2 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 3
743810 | 1B19 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3DB | L41B | 1
743061 | 1CC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41C | 2
756401 | 2AC4 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42C | 3
743903 | 1EC2 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 2
784066 | 2BC3 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 4
743029 | 1AC3 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41C | 2
743895 | 1EC2 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41B | 2
743800 | 1B19 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3D | L41B | 1
756639 | 2DC1 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 4
756581 | 2DC2 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42B | 4
756573 | 2CC1 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 3
743077 | 1CC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 2
756621 | 2DC2 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 4
756679 | 2BC2 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 4
756823 | 2BC6 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 4
756831 | 2BC6 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42B | 4
756747 | 2B22 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 1
756457 | 2AC3 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42C | 3
743053 | 1CC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 2
756501 | 2CC3 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 3
756629 | 2DC2 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42B | 4
743859 | 1B19 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3D | L41B | 1
743085 | 1CC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41C | 2
757715 | 2CC4 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 3
756769 | 2BC4 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42B | 4
743875 | 1AC5 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41C | 1
756787 | 2BC5 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42B | 4
743726 | 1BC2 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 2
756493 | 2CC3 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42C | 3
743764 | 1B19 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3D | L41B | 1
756391 | 2AC4 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 3
756687 | 2BC2 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 4
756671 | 2BC2 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42B | 4
743021 | 1AC3 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 2
756279 | 2A01 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 6
743919 | 1EC4 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 2
743242 | 1DC3 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 2
743234 | 1DC3 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41C | 2
743782 | 1B19 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3DB | L41B | 1
756655 | 2DC1 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42B | 4
756813 | 2BC5 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42B | 4
743426 | 1DC7 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 4
763143 | 2C07 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42C | 2
756447 | 2AC3 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 3
743069 | 1CC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 2
756409 | 2AC4 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 3
743911 | 1EC4 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41B | 2
756605 | 2DC2 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42B | 4
743744 | 1BC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41B | 1
769856 | 2D13 | <not associated> | Level 2 | B3 | L42B | 6
743364 | 1DC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 6
760903 | 2A13 | Linked Revit Model : Clinic_A.rvt | Level 2 | Y2 | L42C | 7
756795 | 2BC5 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 4
756663 | 2DC1 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 4
756483 | 2CC2 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42C | 3
756354 | 2A01 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42C | 6
756355 | 2A01 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 6
756697 | 2BC2 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42B | 4
743678 | 1BC2 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 2
743756 | 1B02 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 1
743434 | 1DC7 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41B | 4
756727 | 2BC3 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42B | 4
756437 | 2AC3 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 3
743408 | 1DC7 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41B | 4
743250 | 1DC3 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41C | 2
743698 | 1B11 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 1
743688 | 1BC2 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41B | 2
743400 | 1DC6 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 4
743226 | 1DC3 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 2
756777 | 2BC5 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 4
756735 | 2BC3 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 4
743666 | 1BC3 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 2
743718 | 1BC2 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 2
743484 | 1E10 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 3
743612 | 1BC4 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 2
756423 | 2AC3 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42C | 3
756613 | 2DC2 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 4
773813 | 2B6 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 3
743442 | 1DC7 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 4
756709 | 2BC3 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42B | 4
756805 | 2BC5 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 4
743476 | 1EC3 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 2
743562 | 1EC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 2
743628 | 1BC4 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41B | 2
743602 | 1BC4 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41B | 2
762838 | 2AC2 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42C | 3
743372 | 1DC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 6
773823 | 2B5 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 3
743736 | 1BC2 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41B | 2
743650 | 1BC3 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 2
756717 | 2BC3 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42B | 4
743418 | 1DC7 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 4
743258 | 1DC3 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 2
743708 | 1B05 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 1
743354 | 1DC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41C | 6
743552 | 1EC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41B | 2
743382 | 1DC5 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41C | 6
762706 | 2AC2 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 3
762673 | 2AC2 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42C | 3
743526 | 1EC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41B | 2
743642 | 1BC4 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 2
743450 | 1DC7 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 4
743582 | 1EC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41B | 2
743594 | 1BC4 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 2
743620 | 1BC4 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 2
743534 | 1EC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 2
743544 | 1EC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 2
743390 | 1D26 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 5
743570 | 1EC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 2
762463 | 2AC5 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 3
762938 | 2C03 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3 | L42C | 2
743312 | 1DC4 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41C | 2
743292 | 1D01 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 3
743276 | 1D04 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 3
762565 | 2AC5 | Linked Revit Model : Clinic_A.rvt | Level 2 | B3B | L42C | 3
743658 | 1BC3 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41B | 2
743268 | 1DC3 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41C | 2
743284 | 1DC2 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41C | 2
743516 | 1EC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 2
743468 | 1DC6 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41B | 4
743508 | 1EC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 2
743460 | 1DC6 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 4
743492 | 1E09 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3 | L41B | 3
743500 | 1EC1 | Linked Revit Model : Clinic_A.rvt | Level 1 | B3B | L41B | 2

# IfcFlowTerminal: 0600x1200mm(2 Lamp) - 120V (439)
Type - ElementType: 0600x1200mm(2 Lamp) - 120V
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Electrical - Lighting - Calculate Coefficient of Utilization: no
PSet_Revit_Electrical - Circuiting - Electrical Data: 120 V/1-80 VA
PSet_Revit_Constraints - Elevation: 2.68 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Photometrics - Light Source Definition (family): Point+HemiSpherical; Light Loss Factor: 0; Initial Intensity: 0; Initial Color: 0; Dimming Lamp Color Temperature Shift: 0; Color Filter: 16777215
PSet_Revit_Type_Electrical - Load Classification: Lighting - Dwelling Unit; Lamp: T-12; Ballast Voltage: 1291.67; Ballast Number of Poles: 1
PSet_Revit_Type_Constraints - Default Elevation: 1.2 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; Assembly Code: D5020210; Assembly Description: Lighting - Fluorescent; OmniClass Number: 23.80.70.11.14.11; OmniClass Title: Downlights
PSet_Revit_Type_Electrical - Loads - Apparent Load: 861.113
PSet_Revit_Type_Dimensions - Light Source Symbol Size: 0.05 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
