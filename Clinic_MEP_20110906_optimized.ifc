Properties of the parts of a building model (IFC2X3), part 294 of 295

# IfcFlowTerminal: Standard (958)
Name (M_Duplex Receptacle:Standard:Standard:...) | In | Mark | Panel | Circuit Number | Host | Elevation (m) | Schedule Level
862692 | 1C18 | 11 | N21C | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
886763 | 1B04 | 221 | N21B | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
862376 | 1C16 | 6 | N21C | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
873900 | 1C07 | 125 | N21C | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
886960 | 1B04 | 223 | N21B | 23 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
874334 | 1C07 | 128 | N21C | 21 | Grid : 4 | 0.5 | Level 1
948017 | 2B17 | 607 | N22B1 | 18 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
951099 | 2B20 | 634 | N22B1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
897296 | 1E25 | 308 | N21E2 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
876400 | 1A16 | 145 | N21B1 | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
968609 | 2A05 | 781 | N22C | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
946088 | 2B17 | 587 | N22B1 | 18 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
878213 | 1A01 | 167 | N21B1 | 27 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
863494 | 1C18 | 17 | N21C | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
867949 | 1C08 | 58 | N21C | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
947410 | 2B14 | 600 | N22B1 | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
946675 | 2B8 | 593 | N22B1 | 22 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
896593 | 1E26 | 299 | N21E2 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
944820 | 2B11 | 575 | N22B1 | 26 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
875039 | Level 1 | 134 | N21B1 | 23 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
968307 | 2A06 | 778 | N22C | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
953246 | 2D21 | 649 | N22B1 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
968922 | 2A05 | 785 | N22C | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
952474 | 2D20 | 637 | N22B1 | 1 | Linked Revit Model : Clinic_S.rvt | 0.5 | Level 2
865467 | 1CC3 | 32 | N21C | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
862253 | 1C16 | 5 | N21C | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
861697 | 1C19 | 1 | N21C | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
864777 | 1C15 | 25 | N21C | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
873814 | 1AC2 | 124 | N21B1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
922307 | 1D19 | 490 | N21C1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
896385 | 1E26 | 295 | N21E2 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
896917 | 1E25 | 303 | N21E2 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
947215 | 2B10 | 596 | N22B1 | 27 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
917289 | 1D20 | 470 | N21C1 | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
886522 | 1B07 | 219 | N21B | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
866278 | 1C09 | 36 | N21C | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
872729 | 1D05 | 114 | N21C1 | 5 | Grid : F | 0.5 | Level 1
944305 | 2B11 | 572 | N22B1 | 26 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
941339 | 2B24 | 548 | N22B1 | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
941049 | 2B23 | 543 | N22B1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
874378 | 1C07 | 129 | N21C | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
897262 | 1E24 | 307 | N21E2 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
862756 | 1C18 | 12 | N21C | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
864995 | 1D16 | 29 | N21C1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
874871 | 1C07 | 131 | N21C | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
949777 | 2BC2 | 621 | N22B1 | 28 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
867075 | 1C04 | 48 | N21C | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
941567 | 2B24 | 550 | N22B1 | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
867254 | 1C04 | 50 | N21C | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
894825 | 1B09 | 283 | N21B | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
967904 | 2A06 | 772 | N22C | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
898626 | 1E24 | 321 | N21E2 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
866511 | 1C09 | 40 | N21C | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
896549 | 1E26 | 298 | N21E2 | 11 | M_Lighting Switches : Single Pole | 0.5 | Level 1
908486 | 1BC4 | 404 | N21B | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
942470 | 2B4 | 560 | N22B1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
879033 | 1A16 | 177 | N21B1 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
968221 | 2A06 | 776 | N22C | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
867563 | 1C04 | 55 | N21C | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
943724 | 2B9 | 568 | N22B1 | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
943681 | 2B7 | 567 | N22B1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
867200 | 1C04 | 49 | N21C | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
884802 | 1B01 | 209 | N21B | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
867456 | 1C08 | 53 | N21C | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
874895 | 1C07 | 132 | N21C | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
884896 | 1B02 | 210 | N21B | 17 | M_Lighting Switches : Single Pole | 0.5 | Level 1
956458 | 2D04-A | 675 | N22B | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
942288 | 2B3 | 558 | N22B1 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
946632 | 2B8 | 592 | N22B1 | 22 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
878501 | 1A16 | 171 | N21B1 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
919903 | 1D25 | 480 | N21E1 | 22 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
877150 | 1A07 | 151 | N21B1 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
973064 | 2A14 | 825 | N22C | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
887484 | 1B04 | 226 | N21B | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
876919 | 1A07 | 149 | N21B1 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
952835 | 2D18 | 645 | N22B | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
897109 | 1E25 | 305 | N21E2 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
878947 | 1A16 | 175 | N21B1 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
863898 | 1C18 | 18 | N21C | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
874291 | 1C07 | 127 | N21C | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
864724 | 1C15 | 24 | N21C | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
928837 | 1D16 | 511 | N21C1 | 16 | Grid : F | 0.5 | Level 1
877236 | 1A07 | 153 | N21B1 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
953911 | 2D02 | 656 | N22B | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
947303 | 2B10 | 598 | N22B1 | 27 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
878990 | 1A16 | 176 | N21B1 | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
987374 | 2C01 | 954 | N22C1 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
887569 | 1B04 | 227 | N21B | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
877904 | 1A03 | 163 | N21B1 | 13 | M_Lighting Switches : Single Pole | 0.5 | Level 1
896228 | 1E27 | 292 | N21E2 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
956521 | 2D04-A | 676 | N22B | 22 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
898520 | 1E24 | 318 | N21E2 | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
953203 | 2D21 | 648 | N22B1 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
941833 | 2B01 | 553 | N22B1 | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
878031 | 1A03 | 164 | N21B1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
951881 | 2D20 | 635 | N22B1 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
953289 | 2D21 | 650 | N22B1 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
876611 | 1A16 | 147 | N21B1 | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
864020 | 1C18 | 21 | N21C | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
947967 | 2B17 | 606 | N22B1 | 29 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
884698 | 1B01 | 208 | N21B | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
921057 | 1D19 | 489 | N21C1 | 14 | Grid : 7 | 0.5 | Level 1
949107 | 2B13 | 617 | N22B1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
949479 | 2BC1 | 620 | N22B | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
898853 | 1E16 | 322 | N21E2 | 26 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
877363 | 1A05 | 155 | N21B1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
967484 | 2A07 | 766 | N22C | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
898544 | 1E22 | 319 | N21E2 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
876286 | 1A16 | 144 | N21B1 | 26 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
866448 | 1C09 | 39 | N21C | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
941203 | 2B24 | 547 | N22B1 | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
878129 | 1A01 | 166 | N21B1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
945829 | 2B25 | 582 | N22B1 | 23 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
908898 | 1DC7 | 408 | N21E1 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
876010 | 1A08 | 140 | N21B1 | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
947715 | 2B14 | 603 | N22B1 | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
873452 | 1DC3 | 122 | N21C1 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
916103 | 1DC1 | 459 | N21E1 | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
953846 | 2D01 | 655 | N22B | 26 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
947620 | 2B14 | 602 | N22B1 | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
882318 | 1A02 | 197 | N21B1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
869402 | 1CC1 | 80 | N21C | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
898582 | 1E20 | 320 | N21E2 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
895427 | 1E28 | 286 | N21E2 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
869190 | 1C02 | 77 | N21C | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
917430 | 1D21 | 473 | N21C1 | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
959158 | 2D15 | 697 | N22B | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
878329 | 1A16 | 169 | N21B1 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
908259 | 1D38 | 403 | N21E1 | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
874228 | 1C07 | 126 | N21C | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
873218 | 1D05 | 119 | N21C1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
947545 | 2B14 | 601 | N22B1 | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
968034 | 2A06 | 775 | N22C | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
895960 | 1E28 | 287 | N21E2 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
877193 | 1A07 | 152 | N21B1 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
888152 | 1B11 | 234 | N21B | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
952741 | 2D21 | 642 | N22B | 29 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
978672 | 2C17 | 892 | N22C1 | 18 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
877290 | 1A05 | 154 | N21B1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
917473 | 1D21 | 474 | N21C1 | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
924752 | 1DC1 | 507 | N21C1 | 3 | Grid : D.9 | 0.5 | Level 1
952772 | 2D21 | 643 | N22B | 29 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
909234 | 1D40 | 411 | N21E1 | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
942395 | 2B3 | 559 | N22B1 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
869273 | 1C01 | 78 | N21C | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
888778 | 1B10 | 240 | N21B | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
919745 | 1D25 | 478 | N21E1 | 22 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
963035 | 2D06 | 736 | N22B | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
951045 | 2B18 | 633 | N22B1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
908685 | 1D40 | 405 | N21E1 | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
967264 | 2A08 | 762 | N22C | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
907473 | 1E33 | 399 | N21E2 | 28 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
945785 | 2B25 | 581 | N22B1 | 23 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
887213 | 1B04 | 225 | N21B | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
949808 | 2BS2 | 622 | N22B1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
959242 | 2D18 | 700 | N22B | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
910193 | 1DC1 | 418 | N21E1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
920262 | 1E33 | 484 | N21E2 | 29 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
886806 | 1B04 | 222 | N21B | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
896014 | 1E28 | 288 | N21E2 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
967029 | 2A08 | 759 | N22C | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
989814 | 2C15 | 963 | N22C1 | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
922511 | 1D12 | 492 | N21C1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
911268 | 1D31 | 425 | N21E1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
908771 | 1D40 | 406 | N21E1 | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
971564 | 2A02 | 811 | N22C | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
868390 | 1C10 | 64 | N21C | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
969815 | 2A03 | 794 | N22C | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
964031 | 2D18 | 739 | N22B | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
877772 | 1A16 | 160 | N21B1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
910984 | 1D33 | 422 | N21E1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
941069 | 2B23 | 544 | N22B1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
946033 | 2B19 | 586 | N22B1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
886468 | 1B04 | 218 | N21B | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
914344 | 1D23 | 455 | N21E1 | 15 | Grid : D.1 | 0.5 | Level 1
867328 | 1CC2 | 51 | N21C | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
891648 | 1A10 | 264 | N21B1 | 22 | Orphaned | 0.5 | Level 1
910470 | 1D33 | 419 | N21E1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
969960 | 2A03 | 795 | N22C | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
967808 | 2A07 | 770 | N22C | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
868304 | 1C10 | 62 | N21C | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
968264 | 2A06 | 777 | N22C | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
872827 | 1D05 | 116 | N21C1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
978421 | 2C16 | 890 | N22C1 | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
968361 | 2A06 | 779 | N22C | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
970625 | 2AC4 | 802 | N22C | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
909069 | 1D37 | 410 | N21E1 | 6 | Grid : C.7 | 0.5 | Level 1
884519 | 1B01 | 207 | N21B | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
973128 | 2AC5 | 826 | N22C | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
891605 | 1A16 | 263 | N21B1 | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
978898 | 2C17 | 895 | N22C1 | 16 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
888014 | 1B06 | 231 | N21B | 20 | M_Lighting Switches : Single Pole | 0.5 | Level 1
920346 | 1D25 | 485 | N21E1 | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
887170 | 1B04 | 224 | N21B | 23 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
876568 | 1A16 | 146 | N21B1 | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
966956 | 2A08 | 758 | N22C | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
872686 | 1D05 | 113 | N21C1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
950293 | 2B16 | 626 | N22B1 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
869317 | 1C07 | 79 | N21C | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
864952 | 1C15 | 28 | N21C | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
949970 | 2BC2 | 623 | N22B1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
969066 | 2A05 | 786 | N22C | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
875275 | 1A09 | 135 | N21B1 | 23 | Grid : G | 0.5 | Level 1
919819 | 1D25 | 479 | N21E1 | 22 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
876192 | 1A16 | 143 | N21B1 | 26 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
972981 | 2A14 | 824 | N22C | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
867031 | 1C05 | 47 | N21C | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
862830 | 1C14 | 13 | N21C | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
986534 | 2C03 | 945 | N22C1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
950746 | 2B16 | 629 | N22B1 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
915487 | 1D22 | 458 | N21E1 | 19 | M_Lighting Switches : Single Pole | 0.5 | Level 1
866723 | 1C05 | 43 | N21C | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
962891 | 2D06 | 735 | N22B | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
878372 | 1A16 | 170 | N21B1 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
902866 | 1E11 | 357 | N21E2 | 30 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
864897 | 1C15 | 27 | N21C | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
864497 | 1C18 | 23 | N21C | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
866565 | 1C09 | 41 | N21C | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
928706 | 1C01 | 510 | N21C | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
872772 | 1D05 | 115 | N21C1 | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
881424 | 1A02 | 193 | N21B1 | 14 | Grid : 1 | 0.5 | Level 1
952859 | 2D18 | 646 | N22B | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
896476 | 1E26 | 297 | N21E2 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
952803 | 2D18 | 644 | N22B | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
945540 | 2BC4 | 580 | N22B1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
869696 | 1C17 | 84 | N21C | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
863977 | 1C18 | 20 | N21C | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
907497 | 1E33 | 400 | N21E2 | 29 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
971271 | 2A13 | 809 | N22C | 18 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
903076 | 1E06 | 360 | N21E2 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
967115 | 2A08 | 761 | N22C | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
957101 | 2DC1 | 681 | N22B | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
873751 | 1D03 | 123 | N21C1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
974635 | 2A10 | 840 | N22C | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
875010 | 1C07 | 133 | N21C | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
979867 | 2C17 | 903 | N22C1 | 21 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
876815 | 1A16 | 148 | N21B1 | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
976998 | 2C09 | 871 | N22C1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
969110 | 2A05 | 787 | N22C | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
962838 | 2D06 | 734 | N22B | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
888207 | 1B06 | 235 | N21B | 22 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
932099 | 1D27 | 521 | N21E1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
896141 | 1E27 | 290 | N21E2 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
970368 | 2A02 | 799 | N22C | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
950116 | 2B14 | 625 | N22B1 | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
967765 | 2A07 | 769 | N22C | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
898358 | 1E24 | 317 | N21E2 | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
913913 | 1D23 | 452 | N21E1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
973528 | 2AC1 | 829 | N22C | 27 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
863934 | 1C18 | 19 | N21C | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
957417 | 2DC2 | 684 | N22B | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
865195 | 1C18 | 30 | N21C | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
897085 | 1E25 | 304 | N21E2 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
970465 | 2A02 | 801 | N22C | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
955292 | 2D04 | 664 | N22B | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
953710 | 2D01 | 654 | N22B | 26 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
913870 | 1D24 | 451 | N21E1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
896782 | 1E29 | 301 | N21E2 | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
908952 | 1DC8 | 409 | N21E1 | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
903030 | 1E07 | 359 | N21E2 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
863260 | 1C14 | 14 | N21C | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
949277 | 2BC6 | 619 | N22B1 | 28 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
870773 | 1D16 | 95 | N21C1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
897584 | 1E24 | 310 | N21E2 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
972938 | 2A14 | 823 | N22C | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
950065 | 2BC3 | 624 | N22B1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
968869 | 2A05 | 784 | N22C | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
976955 | 2C09 | 870 | N22C1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
867854 | 1C08 | 57 | N21C | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
934633 | 1BC4 | 531 | N21B | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
886360 | 1B05 | 216 | N21B | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
970411 | 2A02 | 800 | N22C | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
896703 | 1E29 | 300 | N21E2 | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
873042 | 1D05 | 117 | N21C1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
882529 | 1A02 | 198 | N21B1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
884423 | 1B01 | 206 | N21B | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
985792 | 2C03 | 939 | N22C1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
956147 | 2D04-A | 672 | N22B | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
979782 | 2C17 | 902 | N22C1 | 8 | Linked Revit Model : Clinic_S.rvt | 0.5 | Level 2
956365 | 2D04-A | 674 | N22B | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
871112 | 1D21 | 99 | N21C1 | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
971197 | 2A13 | 808 | N22C | 22 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
868098 | 1C08 | 60 | N21C | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
980076 | 2C17 | 904 | N22C1 | 19 | Linked Revit Model : Clinic_S.rvt | 0.5 | Level 2
899248 | 1E16 | 323 | N21E2 | 26 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
869760 | 1D16 | 85 | N21C1 | 17 | Grid : F | 0.5 | Level 1
945960 | 2B8 | 585 | N22B1 | 22 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
865424 | 1C18 | 31 | N21C | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
957925 | 2D19 | 688 | N22B | 13 | Linked Revit Model : Clinic_S.rvt | 0.5 | Level 2
904453 | 1E03 | 377 | N21E2 | 8 | M_Lighting Switches : Single Pole | 0.5 | Level 1
922371 | 1D15 | 491 | N21C1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
866767 | 1C05 | 44 | N21C | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
955443 | 2D04 | 667 | N22B | 23 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
888064 | 1B08 | 232 | N21B | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
891557 | 1A10 | 262 | N21B1 | 24 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 1
987472 | 2C01 | 956 | N22C1 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
956083 | 2D04-A | 671 | N22B | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
950800 | 2B18 | 630 | N22B1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
957501 | 2D04-A | 685 | N22B | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
911413 | 1D31 | 426 | N21E1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
873145 | 1D05 | 118 | N21C1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
920082 | 1D25 | 482 | N21E1 | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
866865 | 1C05 | 46 | N21C | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
877106 | 1A07 | 150 | N21B1 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
973848 | 2A11 | 831 | N22C | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
973922 | 2A12-A | 832 | N22C | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
930863 | 1DC1 | 519 | N21E1 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
909364 | 1D40 | 413 | N21E1 | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
968652 | 2A05 | 782 | N22C | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
948817 | 2B19 | 615 | N22B1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
971326 | 2A02 | 810 | N22C | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
987258 | 2C01 | 953 | N22C1 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
956862 | 2D04-A | 679 | N22B | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
919516 | 1D25 | 476 | N21E1 | 23 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
970955 | 2A13 | 805 | N22C | 22 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
987418 | 2C01 | 955 | N22C1 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
949150 | 2B12 | 618 | N22B1 | 28 | M_Lighting and Appliance Panelboard - 208V MLO : N22B2 | 0.5 | Level 2
868686 | 1C10 | 68 | N21C | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
870719 | 1D16 | 94 | N21C1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
966743 | 2A09 | 754 | N22C | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
914028 | 1D23 | 453 | N21E1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
881014 | 1A04 | 188 | N21B1 | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
873399 | 1D04 | 121 | N21C1 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
866628 | 1C06 | 42 | N21C | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
986899 | 2C03 | 949 | N22C1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
955683 | 2D04 | 669 | N22B | 23 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
887883 | 1B04 | 229 | N21B | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
945873 | 2B25 | 583 | N22B1 | 23 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
961262 | 2D10 | 719 | N22B | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
946534 | 2BC5 | 591 | N22B1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
884012 | 1B01 | 204 | N21B | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
869018 | 1C02 | 74 | N21C | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
870604 | 1D16 | 93 | N21C1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
948719 | 2B19 | 613 | N22B1 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
895058 | 1B04 | 284 | N21B | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
904653 | 1E02 | 378 | N21E2 | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
956935 | 2D04-A | 680 | N22B | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
914081 | 1D23 | 454 | N21E1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
907373 | 1EC3 | 397 | N21E2 | 30 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
917076 | 1DC1 | 467 | N21C1 | 19 | Grid : D.9 | 0.5 | Level 1
891210 | 1B17 | 259 | N21B | 3 | Grid : C.5 | 0.5 | Level 1
922656 | 1D12 | 493 | N21C1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
896185 | 1E27 | 291 | N21E2 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
868963 | 1C10 | 73 | N21C | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
925140 | 1AC2 | 509 | N21B1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
891721 | 1AC4 | 265 | N21B1 | 20 | Orphaned | 0.5 | Level 1
974823 | 2AC2 | 841 | N22C | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
897232 | 1E25 | 306 | N21E2 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
885220 | 1B03 | 212 | N21B | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
887737 | 1B04 | 228 | N21B | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
975342 | 2C02 | 846 | N22C1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
882190 | 1A02 | 196 | N21B1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
867500 | 1C08 | 54 | N21C | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
986333 | 2C03 | 944 | N22C1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
979346 | 2C17 | 898 | N22C1 | 22 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
968746 | 2A05 | 783 | N22C | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
961956 | 2D09 | 724 | N22B | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
988882 | 2CC2 | 962 | N22C | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
962030 | 2D08 | 725 | N22B | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
878544 | 1A01 | 172 | N21B1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
988850 | 2CC3 | 961 | N22C | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
902812 | 1E11 | 356 | N21E2 | 31 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
876149 | 1A16 | 142 | N21B1 | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
986091 | 2C03 | 942 | N22C1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
923225 | 1D12 | 498 | N21C1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
902759 | 1E11 | 355 | N21E2 | 31 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 1
946195 | 2B8 | 589 | N22B1 | 22 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
923609 | 1DC3 | 501 | N21C1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
978607 | 2C16 | 891 | N22C1 | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
917377 | 1D21 | 472 | N21C1 | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
901625 | 1E15 | 348 | N21E2 | 27 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
916157 | 1DC1 | 460 | N21E1 | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
868426 | 1C10 | 65 | N21C | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
987945 | 2AC1 | 960 | N22C2 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
890740 | 1B21 | 256 | N21B | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
957374 | 2D18 | 683 | N22B | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
950471 | 2B16 | 628 | N22B1 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
975160 | 2C02 | 843 | N22C1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
979739 | 2C17 | 901 | N22C1 | 19 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
883657 | 1AC1 | 202 | N21B1 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
987056 | 2C03 | 950 | N22C1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
876106 | 1A08 | 141 | N21B1 | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
907261 | 1E33 | 396 | N21E2 | 28 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
902631 | 1E07 | 353 | N21E2 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
955389 | 2D04 | 666 | N22B | 23 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
978855 | 2C17 | 894 | N22C1 | 17 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
906563 | 1E11 | 391 | N21E2 | 30 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
960532 | 2D11 | 712 | N22B | 1 | Linked Revit Model : Clinic_S.rvt | 0.5 | Level 2
888399 | 1B06 | 237 | N21B | 22 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
893004 | 1AC1 | 274 | N21B1 | 3 | Grid : D.9 | 0.5 | Level 1
969751 | 2A03 | 793 | N22C | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
869482 | 1C17 | 81 | N21C | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
970097 | 2A03 | 797 | N22C | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
983805 | 2C12 | 927 | N22C1 | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
867383 | 1C08 | 52 | N21C | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
910535 | 1D33 | 420 | N21E1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
908206 | 1D38 | 402 | N21E1 | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
967399 | 2A07 | 765 | N22C | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
970688 | 2A13 | 804 | N22C | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
972325 | 2A14 | 819 | N22C | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
901157 | 1E19 | 345 | N21E2 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
890461 | 1BC4 | 254 | N21B | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
956769 | 2D04-A | 678 | N22B | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
899774 | 1E16 | 324 | N21E2 | 26 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
881287 | 1A02 | 191 | N21B1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
974147 | 2A12 | 835 | N22C | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
923401 | 1D12 | 499 | N21C1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
875966 | 1A10 | 139 | N21B1 | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
866385 | 1C09 | 38 | N21C | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
870910 | 1D20 | 96 | N21C1 | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
959295 | 2D14 | 701 | N22B | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
962764 | 2D06 | 733 | N22B | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
959112 | 2D15 | 696 | N22B | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
962127 | 2D08 | 727 | N22B | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
883499 | Level 1 | 201 | N21B1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
923566 | 1D12 | 500 | N21C1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
911456 | 1D31 | 427 | N21E1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
947809 | 2B15 | 604 | N22B1 | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
908854 | 1D40 | 407 | N21E1 | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
911049 | 1D31 | 423 | N21E1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
979389 | 2C17 | 899 | N22C1 | 21 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
889966 | Level 1 | 249 | N21B | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
977304 | 2CC4 | 875 | N22C1 | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
889038 | 1B10 | 241 | N21B | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
932703 | 1DC6 | 524 | N21E1 | 23 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
969708 | 2A04 | 792 | N22C | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
891401 | 1B17 | 261 | N21B | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
970053 | 2AC3 | 796 | N22C | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
872491 | 1D06 | 110 | N21C1 | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
881528 | 1A02 | 194 | N21B1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
975800 | 2C04 | 853 | N22C1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
897699 | 1E24 | 311 | N21E2 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
920631 | 1D25 | 487 | N21E1 | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
875890 | 1A08 | 138 | N21B1 | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
974092 | 2A12 | 834 | N22C | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
902975 | 1E07 | 358 | N21E2 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
952717 | 2D21 | 641 | N22B | 27 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
974284 | 2A12-A | 836 | N22C | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
869643 | 1C17 | 83 | N21C | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
963199 | 2D06 | 737 | N22B | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
972787 | 2A14 | 821 | N22C | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
967282 | 2A08 | 763 | N22C | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
869126 | 1C02 | 76 | N21C | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
868055 | 1C08 | 59 | N21C | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
877728 | 1A16 | 159 | N21B1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
958827 | 2D15 | 694 | N22B | 16 | Linked Revit Model : Clinic_S.rvt | 0.5 | Level 2
959203 | 2D18 | 699 | N22B | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
975278 | 2C02 | 845 | N22C1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
904429 | 1E05 | 376 | N21E2 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
969655 | 2A04 | 791 | N22C | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
975706 | 2C04 | 852 | N22C1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
970644 | 2A13 | 803 | N22C | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
966657 | 2A09 | 752 | N22C | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
925087 | 1DC1 | 508 | N21E1 | 4 | Grid : D.9 | 0.5 | Level 1
897905 | 1E24 | 312 | N21E2 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
986836 | 2C03 | 948 | N22C1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
900321 | 1E16 | 335 | N21E2 | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
967851 | 2A07 | 771 | N22C | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
982853 | 2C10 | 922 | N22C1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
873261 | 1D05 | 120 | N21C1 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
869082 | 1C02 | 75 | N21C | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
948860 | 2B13 | 616 | N22B1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
892880 | 1A15 | 273 | N21B1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
973465 | 2A11 | 828 | N22C | 27 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
959168 | 2D14 | 698 | N22B | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
957280 | 2D18 | 682 | N22B | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
889193 | 1B10 | 243 | N21B | 11 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 1
868266 | 1CC1 | 61 | N21C | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
909747 | 1DC1 | 415 | N21E1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
872642 | 1D05 | 112 | N21C1 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
950427 | 2B16 | 627 | N22B1 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
980242 | 2C17 | 905 | N22C1 | 20 | Linked Revit Model : Clinic_S.rvt | 0.5 | Level 2
966604 | 2A09 | 751 | N22C | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
978791 | 2C17 | 893 | N22C1 | 23 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
956656 | 2D04-A | 677 | N22B | 22 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
956302 | 2D04-A | 673 | N22B | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
882999 | 1AC1 | 199 | N21B1 | 2 | Grid : D.9 | 0.5 | Level 1
961306 | 2D09 | 720 | N22B | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
978378 | 2C16 | 889 | N22C1 | 6 | Linked Revit Model : Clinic_S.rvt | 0.5 | Level 2
906309 | 1E08 | 388 | N21E2 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
976830 | 2C09 | 869 | N22C1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
974529 | 2A10 | 839 | N22C | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
976460 | 2C06 | 863 | N22C1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
923972 | 1DC1 | 504 | N21C1 | 10 | Grid : D.9 | 0.5 | Level 1
971069 | 2A13 | 806 | N22C | 18 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
974338 | 2AC3 | 837 | N22C | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
986648 | 2C03 | 946 | N22C1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
962438 | 2D07 | 732 | N22B | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
961808 | 2D09 | 722 | N22B | 5 | Linked Revit Model : Clinic_S.rvt | 0.5 | Level 2
863323 | 1C14 | 15 | N21C | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
890615 | 1B23 | 255 | N21B | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
967072 | 2A08 | 760 | N22C | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
915083 | 1D22 | 457 | N21E1 | 15 | <not associated> | 0.5 | Level 1
910107 | 1DC1 | 416 | N21E1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
958370 | 2D17 | 691 | N22B | 15 | Linked Revit Model : Clinic_S.rvt | 0.5 | Level 2
909320 | 1D40 | 412 | N21E1 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
912931 | 1D25 | 439 | N21E1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
987109 | 2C03 | 951 | N22C1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
903614 | 1EC1 | 367 | N21E2 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
870118 | 1D16 | 88 | N21C1 | 18 | <not associated> | 0.5 | Level 1
875506 | 1A08 | 137 | N21B1 | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
987890 | 2AC1 | 959 | N22C | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
868775 | 1C10 | 70 | N21C | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
871280 | 1D17 | 101 | N21C1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
977939 | 2C14 | 883 | N22C1 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
979092 | 2C17 | 896 | N22C1 | 8 | Linked Revit Model : Clinic_S.rvt | 0.5 | Level 2
868817 | 1C10 | 71 | N21C | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
907531 | 1D38 | 401 | N21E1 | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
907147 | 1E33 | 395 | N21E2 | 28 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
911740 | 1D30 | 430 | N21E1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
903780 | 1E04 | 370 | N21E2 | 6 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 1
967527 | 2A07 | 767 | N22C | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
987153 | 2C05 | 952 | N22C1 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
965276 | 2DC2 | 742 | N22B | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
903511 | 1E06 | 366 | N21E2 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
912782 | 1D26 | 438 | N21E1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
979229 | 2C17 | 897 | N22C1 | 22 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
883835 | 1AC1 | 203 | N21B1 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
934261 | 1A10 | 528 | N21B1 | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
919591 | 1D25 | 477 | N21E1 | 23 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
959358 | 2D14 | 702 | N22B | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
889222 | 1B10 | 244 | N21B | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
891830 | 1A14 | 267 | N21B1 | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
870508 | 1D16 | 91 | N21C1 | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
934497 | 1B17 | 530 | N21B | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
961066 | 2D10 | 716 | N22B | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
910129 | 1DC1 | 417 | N21E1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
972179 | 2A01 | 817 | N22C | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
987610 | 2C01 | 957 | N22C1 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
934961 | 1B13 | 534 | N21B | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
974844 | 2C02 | 842 | N22C1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
903391 | 1E06 | 365 | N21E2 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
870975 | 1D20 | 97 | N21C1 | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
955335 | 2D04 | 665 | N22B | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
888578 | 1B08 | 239 | N21B | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
957852 | 2D19 | 687 | N22B | 13 | Orphaned | 0.5 | Level 2
966903 | 2A08 | 757 | N22C | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
909712 | 1DC1 | 414 | N21E1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
871598 | 1D07 | 103 | N21C1 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
979665 | 2C17 | 900 | N22C1 | 19 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
934822 | 1BC2 | 532 | N21B | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
935031 | Level 1 | 535 | N21B | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
984323 | 2CC3 | 929 | N22C | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
911551 | 1D30 | 428 | N21E1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
913624 | 1DC1 | 447 | N21E1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
900886 | 1E16 | 340 | N21E2 | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
899818 | 1E16 | 325 | N21E2 | 24 | <not associated> | 0.5 | Level 1
919997 | 1E14 | 481 | N21E2 | 27 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
864443 | 1C18 | 22 | N21C | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
948294 | 2B15 | 610 | N22B1 | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
948762 | 2B19 | 614 | N22B1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
959531 | 2D14 | 703 | N22B | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
982205 | 2C19 | 917 | N22C1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
898098 | 1E23 | 314 | N21E2 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
920178 | 1D25 | 483 | N21E1 | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
902558 | 1E07 | 352 | N21E2 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
971124 | 2A13 | 807 | N22C | 18 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
881889 | 1A02 | 195 | N21B1 | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
900292 | 1E18 | 334 | N21E2 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
972885 | 2A14 | 822 | N22C | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
973729 | 2A11 | 830 | N22C | 27 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
903809 | 1E04 | 371 | N21E2 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
879636 | 1A16 | 179 | N21B1 | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
929699 | 1DC1 | 516 | N21E1 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
890125 | 1E29 | 250 | N21E2 | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
957576 | 2D19 | 686 | N22B | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
975969 | 2C04 | 857 | N22C1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
954251 | 2D03 | 661 | N22B | 28 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
866821 | 1C05 | 45 | N21C | 15 | Grid : 5 | 0.5 | Level 1
871216 | 1D16 | 100 | N21C1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
872448 | 1D07 | 109 | N21C1 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
962084 | 2D08 | 726 | N22B | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
961480 | 2D18 | 721 | N22B | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
953087 | 2D21 | 647 | N22B1 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
985491 | 2C22 | 936 | N22C1 | 26 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
954399 | 2D03 | 662 | N22B | 28 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
934216 | 1A13 | 527 | N21B1 | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
891157 | 1B17 | 258 | N21B | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
879441 | 1A16 | 178 | N21B1 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
974453 | 2A11 | 838 | N22C | 26 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
887927 | 1B04 | 230 | N21B | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
867689 | 1C08 | 56 | N21C | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
905074 | 1D38 | 379 | N21E1 | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
886106 | 1B03 | 214 | N21B | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
916970 | 1D22 | 466 | N21E1 | 15 | Grid : D.9 | 0.5 | Level 1
875401 | 1AC3 | 136 | N21B1 | 23 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
868938 | 1C10 | 72 | N21C | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
906151 | 1E06 | 386 | N21E2 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
879659 | 1A16 | 180 | N21B1 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
903734 | 1E04 | 369 | N21E2 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
884298 | 1B01 | 205 | N21B | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
955516 | 2D04 | 668 | N22B | 23 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
975436 | 2C02 | 847 | N22C1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
888374 | 1B06 | 236 | N21B | 22 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
903101 | 1E06 | 361 | N21E2 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
945487 | 2B5 | 579 | N22B1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
987663 | 2C23 | 958 | N22C2 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
976669 | 2C09 | 866 | N22C1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
929097 | 1DC4 | 514 | N21C1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
894123 | 1B13 | 278 | N21B | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
913827 | 1D24 | 450 | N21E1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
880597 | 1A06 | 183 | N21B1 | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
965014 | 2BC3 | 741 | N22B1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
950888 | 2B18 | 632 | N22B1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
931881 | 1D39 | 520 | N21E1 | 6 | M_Lighting Switches : Single Pole | 0.5 | Level 1
916357 | 1D22 | 461 | N21E1 | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
916748 | 1D22 | 465 | N21E1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
888107 | 1B04 | 233 | N21B | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
966520 | 2A09 | 750 | N22C | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
966466 | 2A09 | 749 | N22C | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
889073 | 1B10 | 242 | N21B | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
901019 | 1E16 | 343 | N21E2 | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
883272 | Level 1 | 200 | N21B1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
896867 | 1E29 | 302 | N21E2 | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
885156 | 1BC1 | 211 | N21B | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
893532 | 1AC1 | 276 | N21B1 | 2 | Grid : D.9 | 0.5 | Level 1
985718 | 2C03 | 938 | N22C1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
959843 | 2D16 | 706 | N22B | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
871038 | 1D21 | 98 | N21C1 | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
872567 | 1D06 | 111 | N21C1 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
975867 | 2C06 | 855 | N22C1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
911979 | 1DC7 | 432 | N21E1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
972368 | 2A14 | 820 | N22C | 23 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
918957 | 1D25 | 475 | N21E1 | 23 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
948329 | 2B15 | 611 | N22B1 | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
894198 | 1B13 | 279 | N21B | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
954543 | 2D04 | 663 | N22B | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
961233 | 2D10 | 718 | N22B | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
907413 | 1E33 | 398 | N21E2 | 28 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
898070 | 1E24 | 313 | N21E2 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
913774 | 1D24 | 449 | N21E1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
898273 | 1E24 | 315 | N21E2 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
870551 | 1D16 | 92 | N21C1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
967722 | 2A07 | 768 | N22C | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
956019 | 2D04 | 670 | N22B | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
981419 | 2C18 | 912 | N22C1 | 16 | M_Lighting and Appliance Panelboard - 208V MLO : L42C | 0.5 | Level 2
946152 | 2B17 | 588 | N22B1 | 19 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
899961 | 1E16 | 327 | N21E2 | 25 | <not associated> | 0.5 | Level 1
902340 | 1E10 | 350 | N21E2 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
929170 | 1D15 | 515 | N21C1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
962171 | 2D08 | 728 | N22B | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
924670 | 1DC1 | 506 | N21C1 | 10 | Grid : D.9 | 0.5 | Level 1
960795 | 2D11 | 713 | N22B | 1 | Linked Revit Model : Clinic_S.rvt | 0.5 | Level 2
899992 | 1E16 | 328 | N21E2 | 23 | <not associated> | 0.5 | Level 1
891357 | 1B13 | 260 | N21B | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
910579 | 1D33 | 421 | N21E1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
903176 | 1E08 | 363 | N21E2 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
948359 | 2B19 | 612 | N22B1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
963263 | 2D18 | 738 | N22B | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
952622 | 2D20 | 639 | N22B1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
903212 | 1E06 | 364 | N21E2 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
975489 | 2C02 | 848 | N22C1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
903688 | 1E06 | 368 | N21E2 | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
904184 | 1E05 | 373 | N21E2 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
952661 | 2D21 | 640 | N22B | 27 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
911824 | 1D30 | 431 | N21E1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
880841 | 1A06 | 185 | N21B1 | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
888453 | 1B06 | 238 | N21B | 22 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
978023 | 2C14 | 884 | N22C1 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
986279 | 2C03 | 943 | N22C1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
904009 | 1E04 | 372 | N21E2 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
959886 | 2D16 | 707 | N22B | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
973214 | 2A11 | 827 | N22C | 27 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
924536 | 1DC1 | 505 | N21C1 | 10 | Grid : D.9 | 0.5 | Level 1
901377 | 1E14 | 347 | N21E2 | 27 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
914439 | 1D22 | 456 | N21E1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
976209 | 2C06 | 861 | N22C1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
975662 | 2C04 | 851 | N22C1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
982005 | 2C19 | 916 | N22C1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
881202 | 1AC5 | 190 | N21B1 | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
985846 | 2C03 | 940 | N22C1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
920545 | 1E15 | 486 | N21E2 | 27 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
917333 | 1D19 | 471 | N21C1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
975543 | 2C04 | 849 | N22C1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
889426 | 1B12 | 246 | N21B | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
891765 | 1A12 | 266 | N21B1 | 23 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
868587 | 1C10 | 67 | N21C | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
932133 | 1D27 | 522 | N21E1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
892671 | 1A15 | 271 | N21B1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
906205 | 1E06 | 387 | N21E2 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
983014 | 2C12 | 923 | N22C1 | 16 | Orphaned | 0.5 | Level 2
977577 | 2CC4 | 877 | N22C1 | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
890397 | 1E04 | 253 | N21E2 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
966806 | 2A09 | 755 | N22C | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
900911 | 1E16 | 341 | N21E2 | 18 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
901709 | 1EC1 | 349 | N21E2 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
982476 | 2C10 | 920 | N22C1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
898319 | 1E30 | 316 | N21E2 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
902668 | 1E11 | 354 | N21E2 | 31 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 1
960949 | 2D11 | 714 | N22B | 1 | Linked Revit Model : Clinic_S.rvt | 0.5 | Level 2
983707 | 2C12 | 925 | N22C1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.65 | Level 2
977721 | 2C14 | 881 | N22C1 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
894338 | 1BC2 | 281 | N21B | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
885451 | 1B03 | 213 | N21B | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
958733 | 2D15 | 693 | N22B | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
881128 | 1A04 | 189 | N21B1 | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
985333 | 2C22 | 935 | N22C1 | 15 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
905149 | 1D38 | 380 | N21E1 | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
977618 | 2C13 | 878 | N22C1 | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
923756 | 1D01 | 502 | N21C1 | 3 | Grid : E.2 | 0.5 | Level 1
889817 | 1B16 | 248 | N21B | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
986691 | 2C03 | 947 | N22C1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
972222 | 2A14 | 818 | N22C | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
958880 | 2D17 | 695 | N22B | 15 | Orphaned | 0.5 | Level 2
962322 | 2D07 | 731 | N22B | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
978292 | 2C16 | 887 | N22C1 | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
977660 | 2C14 | 879 | N22C1 | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
983891 | 2C10 | 928 | N22C1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
890991 | 1B17 | 257 | N21B | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
923037 | 1D14 | 497 | N21C1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
976144 | 2C06 | 860 | N22C1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
934906 | 1B15 | 533 | N21B | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
980380 | 2C17 | 907 | N22C1 | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
906404 | 1E08 | 389 | N21E2 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
965999 | 2D05 | 748 | N22C1 | 24 | Linked Revit Model : Clinic_S.rvt | 0.5 | Level 2
901093 | Level 1 | 344 | N21E2 | 27 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
966700 | 2A09 | 753 | N22C | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
976407 | 2C06 | 862 | N22C1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
