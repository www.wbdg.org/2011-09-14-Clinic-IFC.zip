Properties of the parts of a building model (IFC2X3), part 83 of 295

# IfcFlowSegment: Pipe Types:Cold Water:691051
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691074
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691074
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 0.38555 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 10521.2; Section: 45; Area: 0.0216958 m2
PSet_Revit_Identity Data - Mark: 2236
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.4604 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.84595 m; Start Offset: 0.84595 m; End Offset: 0.38555 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691075
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691075
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.371263 m; Start Offset: 0.371263 m; End Offset: 0.371263 m; Slope: 0
PSet_Revit_Identity Data - Mark: 2237
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 0.365933 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 4122.07; Section: 45; Area: 0.00850012 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.180378 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691078
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691078
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.0729359 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 0.365933 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 1666.76; Section: 45; Area: 0.00343702 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 2238
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.371263 m; Start Offset: 0.371263 m; End Offset: 0.371263 m; Slope: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691087
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691087
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: -0.40533 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 44250; Section: 42; Area: 0.091248 m2
PSet_Revit_Identity Data - Mark: 2239
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 1.93634 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691092
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691092
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 3; Insulation Thickness: 0; Invert Elevation: -0.408105 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 66232.2; Relative Roughness: 6381.89; Flow State: 2; Friction Factor: 0.0130723; Velocity: 15.0447; Friction: 786.845; Pressure Drop: 6241.41; Section: 44; Area: 0.151911 m2
PSet_Revit_Dimensions - Outer Diameter: 0.0625; Inner Diameter: 0.0531824; Size: 20 mmø; Diameter: 0.0656168; Length: 2.41773 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 2240
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691133
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691133
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: -0.385713 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 16972.2; Section: 42; Area: 0.0349983 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 2242
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.742688 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.385713 m; Start Offset: -0.385713 m; End Offset: 0.356975 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691170
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691170
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.84595 m; Start Offset: 0.84595 m; End Offset: 0.38555 m
PSet_Revit_Identity Data - Mark: 2243
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 0.38555 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 10521.2; Section: 42; Area: 0.0216958 m2
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.4604 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691171
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691171
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.371263 m; Start Offset: 0.371263 m; End Offset: 0.371263 m; Slope: 0
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 0.365933 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 4122.07; Section: 42; Area: 0.00850012 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 2244
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.180378 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691174
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691174
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.371263 m; Start Offset: 0.371263 m; End Offset: 0.371263 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 1.5; Insulation Thickness: 0; Invert Elevation: 0.365933 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 1309.02; Section: 42; Area: 0.00269934 m2
PSet_Revit_Identity Data - Mark: 2245
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.0572817 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691183
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691183
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 2246
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 3; Insulation Thickness: 0; Invert Elevation: -0.40533 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 50191.7; Section: 320; Area: 0.1035 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 2.19634 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691188
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691188
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.0625; Inner Diameter: 0.0531824; Size: 20 mmø; Diameter: 0.0656168; Length: 1.57036 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: -0.408105 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 6381.89; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 478; Area: 0.0986689 m2
PSet_Revit_Identity Data - Mark: 2247
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691234
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691234
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 2249
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 3; Insulation Thickness: 0; Invert Elevation: -0.385713 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 16972.2; Section: 320; Area: 0.0349983 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.742688 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.385713 m; Start Offset: -0.385713 m; End Offset: 0.356975 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691259
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691259
PSet_Revit_Identity Data - Mark: 2252
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 3; Insulation Thickness: 0; Invert Elevation: 0.365933 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 5592.15; Section: 320; Area: 0.0115316 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.244708 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.371263 m; Start Offset: 0.371263 m; End Offset: 0.371263 m; Slope: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691268
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691268
PSet_Revit_Dimensions - Outer Diameter: 0.0833333; Inner Diameter: 0.0740157; Size: 25 mmø; Diameter: 0.082021; Length: 0.732375 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: -0.41128 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 8881.89; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 484; Area: 0.0575206 m2
PSet_Revit_Identity Data - Mark: 2253
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691275
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691275
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: -0.41128 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 8881.89; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 476; Area: 0.238873 m2
PSet_Revit_Identity Data - Mark: 2254
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.0833333; Inner Diameter: 0.0740157; Size: 25 mmø; Diameter: 0.082021; Length: 3.04143 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691277
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691277
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.2 m; Start Offset: 0.2 m; End Offset: 0.2 m; Slope: 0
PSet_Revit_Identity Data - Mark: 2255
PSet_Revit_Dimensions - Outer Diameter: 0.0833333; Inner Diameter: 0.0740157; Size: 25 mmø; Diameter: 0.082021; Length: 0.119363 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 0.18872 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 8881.89; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 484; Area: 0.00937471 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691315
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691315
PSet_Revit_Dimensions - Outer Diameter: 0.0833333; Inner Diameter: 0.0740157; Size: 25 mmø; Diameter: 0.082021; Length: 0.558725 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.379363 m; Start Offset: -0.379363 m; End Offset: 0.179363 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: -0.379363 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 8881.89; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 484; Area: 0.0438822 m2
PSet_Revit_Identity Data - Mark: 2256
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691325
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691325
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 3; Insulation Thickness: 0; Invert Elevation: -0.40533 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 72305.2; Section: 322; Area: 0.149101 m2
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 3.16401 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 2257
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691332
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691332
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 2258
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.0833333; Inner Diameter: 0.0740157; Size: 25 mmø; Diameter: 0.082021; Length: 0.871672 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: -0.41128 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 8881.89; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 475; Area: 0.068461 m2
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691336
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691336
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.671425 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 3; Insulation Thickness: 0; Invert Elevation: -0.40533 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 15343.7; Section: 322; Area: 0.0316402 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 2259
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691375
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691375
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 3; Insulation Thickness: 0; Invert Elevation: -0.385713 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 16972.2; Section: 322; Area: 0.0349983 m2
PSet_Revit_Identity Data - Mark: 2261
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.742688 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.385713 m; Start Offset: -0.385713 m; End Offset: 0.356975 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691400
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691400
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 3; Insulation Thickness: 0; Invert Elevation: 0.365933 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 100715; Relative Roughness: 4196.85; Flow State: 2; Friction Factor: 0.0142324; Velocity: 34.7884; Friction: 6965.4; Pressure Drop: 1318.57; Section: 322; Area: 0.00271903 m2
PSet_Revit_Identity Data - Mark: 2264
PSet_Revit_Dimensions - Outer Diameter: 0.0416667; Inner Diameter: 0.0349738; Size: 15 mmø; Diameter: 0.0492126; Length: 0.0576997 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 0.371263 m; Start Offset: 0.371263 m; End Offset: 0.371263 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691434
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691434
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: -0.41128 m; Additional Flow: 0; Flow: 0; Reynolds Number: 0; Relative Roughness: 8881.89; Flow State: 0; Friction Factor: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Section: 473; Area: 0.05473 m2
PSet_Revit_Dimensions - Outer Diameter: 0.0833333; Inner Diameter: 0.0740157; Size: 25 mmø; Diameter: 0.082021; Length: 0.696844 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 2265
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic

# IfcFlowSegment: Pipe Types:Cold Water:691511
In: Level 1
Type - ElementType: Pipe Types:Cold Water:691511
PSet_Revit_Mechanical - System Type: Domestic Cold Water; System Name: Domestic Cold Water 1; Fixture Units: 3.75; Insulation Thickness: 0; Invert Elevation: -0.42377 m; Additional Flow: 0; Flow: 0.0334201; Reynolds Number: 22583.6; Relative Roughness: 18716.5; Flow State: 2; Friction Factor: 0.0106702; Velocity: 1.74916; Friction: 2.96026; Pressure Drop: 9.79823; Section: 155; Area: 0.158472 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: -0.4 m; Start Offset: -0.4 m; End Offset: -0.4 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.166667; Inner Diameter: 0.155971; Size: 50 mmø; Diameter: 0.164042; Length: 1.00886 m
PSet_Revit_Identity Data - Mark: 2267
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Copper; Connection Type: Soldered; Class: A
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
