Properties of the parts of a building model (IFC2X3), part 187 of 295

# IfcFlowSegment: Pipe Types:Vent:658519
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:658565
In: Level 2
Type - ElementType: Pipe Types:Vent:658565
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.197917; Inner Diameter: 0.17225; Size: 50 mmø; Diameter: 0.164042; Length: 0.157231 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.59692 m; Start Offset: -1.59692 m; End Offset: -1.43969 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1242
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 2.97308 m; Section: 506; Area: 0.0246978 m2
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:658651
In: Level 2
Type - ElementType: Pipe Types:Vent:658651
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.44955 m; Section: 491; Area: 0.0884313 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 0.703714 m
PSet_Revit_Identity Data - Mark: 1253
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.9 m; Start Offset: 2.9 m; End Offset: 2.9 m; Slope: 0
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:658693
In: Level 2
Type - ElementType: Pipe Types:Vent:658693
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.44955 m; Section: 483; Area: 0.0830877 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.9 m; Start Offset: 2.9 m; End Offset: 2.9 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 0.661191 m
PSet_Revit_Identity Data - Mark: 1256
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:658756
In: Level 2
Type - ElementType: Pipe Types:Vent:658756
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.93969 m; Start Offset: 2.93969 m; End Offset: 4.95 m
PSet_Revit_Dimensions - Outer Diameter: 0.197917; Inner Diameter: 0.17225; Size: 50 mmø; Diameter: 0.164042; Length: 2.01031 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.50969 m; Section: 497; Area: 0.315779 m2
PSet_Revit_Identity Data - Mark: 1257
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:658828
In: Level 2
Type - ElementType: Pipe Types:Vent:658828
PSet_Revit_Identity Data - Mark: 1260
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.9 m; Start Offset: 2.9 m; End Offset: 2.9 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 0.267072 m
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.44955 m; Section: 483; Area: 0.0335612 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:658842
In: Level 2
Type - ElementType: Pipe Types:Vent:658842
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 0.193001 m
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.44955 m; Section: 494; Area: 0.0242533 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.9 m; Start Offset: 2.9 m; End Offset: 2.9 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1261
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:659024
In: Level 2
Type - ElementType: Pipe Types:Vent:659024
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 1.44421 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.44955 m; Section: 494; Area: 0.181485 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.9 m; Start Offset: 2.9 m; End Offset: 2.9 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1264
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:659099
In: Level 2
Type - ElementType: Pipe Types:Vent:659099
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 3.14955 m; Section: 495; Area: 0.010972 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.4 m; Start Offset: -1.4 m; End Offset: -1.4 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1268
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 0.0873126 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:659106
In: Level 2
Type - ElementType: Pipe Types:Vent:659106
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.66121 m; Start Offset: -1.66121 m; End Offset: -1.42699 m
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 0.234225 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1269
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 2.90879 m; Section: 495; Area: 0.0294336 m2
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:659112
In: Level 2
Type - ElementType: Pipe Types:Vent:659112
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 4.23968 m
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 3.19699 m; Section: 495; Area: 0.532773 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1270
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.86666 m; Start Offset: 2.86666 m; End Offset: -1.37301 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:659114
In: Level 2
Type - ElementType: Pipe Types:Vent:659114
PSet_Revit_Identity Data - Mark: 1271
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.44955 m; Section: 492; Area: 0.255841 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 2.9 m; Start Offset: 2.9 m; End Offset: 2.9 m; Slope: 0
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 2.03592 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:659299
In: Level 2
Type - ElementType: Pipe Types:Vent:659299
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.1 m; Start Offset: 3.1 m; End Offset: 3.1 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1282
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 0.209623 m
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.64955 m; Section: 436; Area: 0.0263419 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:659354
In: Level 2
Type - ElementType: Pipe Types:Vent:659354
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.66121 m; Start Offset: -1.66121 m; End Offset: 3.07301 m
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 4.73423 m
PSet_Revit_Identity Data - Mark: 1283
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 2.90879 m; Section: 436; Area: 0.59492 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:659359
In: Level 2
Type - ElementType: Pipe Types:Vent:659359
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.64955 m; Section: 436; Area: 0.392301 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.1 m; Start Offset: 3.1 m; End Offset: 3.1 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1284
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 3.12183 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:659368
In: Level 2
Type - ElementType: Pipe Types:Vent:659368
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.1 m; Start Offset: 3.1 m; End Offset: 3.1 m; Slope: 0
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.64955 m; Section: 436; Area: 0.0404428 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 0.321834 m
PSet_Revit_Identity Data - Mark: 1285
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:659375
In: Level 2
Type - ElementType: Pipe Types:Vent:659375
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.1 m; Start Offset: 3.1 m; End Offset: 3.1 m; Slope: 0
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.64955 m; Section: 436; Area: 0.0430588 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 0.342651 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 1286
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:659471
In: Level 2
Type - ElementType: Pipe Types:Vent:659471
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 0.732669 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3 m; Start Offset: 3 m; End Offset: 3 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1287
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.54955 m; Section: 472; Area: 0.0920699 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:659482
In: Level 2
Type - ElementType: Pipe Types:Vent:659482
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3 m; Start Offset: 3 m; End Offset: 3 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 2.76397 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.54955 m; Section: 472; Area: 0.347331 m2
PSet_Revit_Identity Data - Mark: 1289
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:659494
In: Level 2
Type - ElementType: Pipe Types:Vent:659494
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 0.357913 m
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.54955 m; Section: 445; Area: 0.0449767 m2
PSet_Revit_Identity Data - Mark: 1290
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3 m; Start Offset: 3 m; End Offset: 3 m; Slope: 0
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:659502
In: Level 2
Type - ElementType: Pipe Types:Vent:659502
PSet_Revit_Identity Data - Mark: 1291
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 0.109092 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3 m; Start Offset: 3 m; End Offset: 3 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.54955 m; Section: 462; Area: 0.0137089 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:659507
In: Level 2
Type - ElementType: Pipe Types:Vent:659507
PSet_Revit_Identity Data - Mark: 1292
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3 m; Start Offset: 3 m; End Offset: 3 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 1.08531 m
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.54955 m; Section: 445; Area: 0.136383 m2
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:659516
In: Level 2
Type - ElementType: Pipe Types:Vent:659516
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.54955 m; Section: 442; Area: 0.372443 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3 m; Start Offset: 3 m; End Offset: 3 m; Slope: 0
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1293
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 2.96381 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:659521
In: Level 2
Type - ElementType: Pipe Types:Vent:659521
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3 m; Start Offset: 3 m; End Offset: 3 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.54955 m; Section: 464; Area: 0.112663 m2
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 0.896544 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1294
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:659523
In: Level 2
Type - ElementType: Pipe Types:Vent:659523
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.54955 m; Section: 442; Area: 0.0327677 m2
PSet_Revit_Identity Data - Mark: 1295
PSet_Revit_Dimensions - Outer Diameter: 0.158333; Inner Diameter: 0.134167; Size: 40 mmø; Diameter: 0.131234; Length: 0.260757 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3 m; Start Offset: 3 m; End Offset: 3 m; Slope: 0
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:660017
In: Level 2
Type - ElementType: Pipe Types:Vent:660017
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 2.91514 m; Section: 459; Area: 0.72495 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: -1.65486 m; Start Offset: -1.65486 m; End Offset: 2.96031 m
PSet_Revit_Identity Data - Mark: 1309
PSet_Revit_Dimensions - Outer Diameter: 0.197917; Inner Diameter: 0.17225; Size: 50 mmø; Diameter: 0.164042; Length: 4.61518 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:660038
In: Level 2
Type - ElementType: Pipe Types:Vent:660038
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.70969 m; Section: 441; Area: 0.284363 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Outer Diameter: 0.197917; Inner Diameter: 0.17225; Size: 50 mmø; Diameter: 0.164042; Length: 1.81031 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.13969 m; Start Offset: 3.13969 m; End Offset: 4.95 m
PSet_Revit_Identity Data - Mark: 1310
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-60 30 11 11; Classification Description: Pipes for General Use; ModelLabel: ModelLabel
PSet_Revit_Type_Fitting - Elbow: M_Elbow - Generic: Elbow - Generic; Preferred Junction Type: 1; Tee: M_Tee - Generic: Tee - Generic; Cross: M_Cross - Generic: Cross - Generic; Transition: M_Transition - Generic: Transition - Generic; Union: M_Coupling - Generic: Coupling - Generic
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Mechanical - Roughness: 0.00000833333; Material: Plastic; Connection Type: Threaded; Class: Schedule 40

# IfcFlowSegment: Pipe Types:Vent:660044
In: Level 2
Type - ElementType: Pipe Types:Vent:660044
PSet_Revit_Dimensions - Outer Diameter: 0.197917; Inner Diameter: 0.17225; Size: 50 mmø; Diameter: 0.164042; Length: 0.020625 m
PSet_Revit_Identity Data - Mark: 1311
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.03969 m; Start Offset: 3.03969 m; End Offset: 3.06031 m
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1; Fixture Units: 0; Insulation Thickness: 0; Invert Elevation: 7.60969 m; Section: 463; Area: 0.00323977 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
