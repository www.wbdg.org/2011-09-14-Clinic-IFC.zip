Properties of the parts of a building model (IFC2X3), part 292 of 295

# IfcFlowTerminal: 2400mm - 120V (13)
Name (M_Pendant Light - Linear - 2 Lamp:2400mm - 120V:2400mm - 120V:...) | In | Elevation (m) | Schedule Level | Panel | Circuit Number
777758 | 2D18 | 2.68 | Level 2 | L42B | 5
777413 | 2D18 | 2.68 | Level 2 | L42B | 5
746278 | 1DC1 | 2.8 | Level 1 | L41C | 6
746576 | 1DC1 | 2.68 | Level 1 | L41C | 6
777306 | 2D18 | 2.68 | Level 2 | L42B | 5
777540 | 2D18 | 2.68 | Level 2 | L42B | 5
777702 | 2D18 | 2.68 | Level 2 | L42B | 5
777566 | 2D18 | 2.68 | Level 2 | L42B | 5

# IfcFlowTerminal: 25 mm Flush Valve (3)
Type - ElementType: 25 mm Flush Valve; PredefinedType: URINAL
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Plumbing - Flow Pressure: 31522.7
PSet_Revit_Mechanical - System Type: Sanitary,Domestic Cold Water; System Name: Sanitary 1,Domestic Cold Water 1
PSet_Revit_Constraints - Host: Linked Revit Model : Clinic_A.rvt; Elevation: 0.43 m
PSet_Revit_Other - TagNumber: P8150; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; Type Mark: P8150; OmniClass Number: 23.45.05.21.11.21; OmniClass Title: Urinals
PSet_Revit_Type_Dimensions - Urinal Width: 0.45 m; Urinal Length: 0.445 m; Urinal Height: 0.66 m; Sanitary Radius: 0.082021; Sanitary Diameter: 0.164042; Cold Water Radius: 0.0328084; Cold Water Diameter: 0.0656168
PSet_Revit_Type_Constraints - Default Elevation: 0.43 m
PSet_Revit_Type_Mechanical - WFU: 4; HWFU: 0; CWFU: 10
PSet_Revit_Type_Other - Height1: 0.365 m; Half Urinal Width: 0.225 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Urinal - Wall Hung:25 mm Flush Valve:25 mm Flush Valve:...) | In | Mark | Schedule Level
652788 | 2C07 | 104 | Level 2
651923 | 2C23 | 95 | Level 2
621238 | 1A12 | 59 | Level 1

# IfcFlowTerminal: 300 x 300 Face 300 x 300 Connection 2 (17)
Type - ElementType: 300 x 300 Face 300 x 300 Connection 2
PSet_Revit_Constraints - Offset: 2.8 m
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Pressure Drop: 4.2672; Flow: 8.29895
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - UpArrow: yes; RightArrow: yes; LeftArrow: yes; DownArrow: yes; System Type: Return Air
PSet_Revit_Type_Other - Width 1: 0.195 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles
PSet_Revit_Type_Dimensions - Duct Width: 0.984252; Duct Height: 0.984252; Diffuser Width: 0.3 m; Diffuser Height: 0.3 m
Name (M_Return Diffuser:300 x 300 Face 300 x 300 Connection 2:300 x 300 Face 300 x 300 Connection 2:...) | In | Level | Host | Mark = TagNumber | System Name
1090734 | 1E14 | Level 1 | Rectangular Duct : Mitered Elbows / Tees | D | Mechanical Return Air 1
567102 | 1E28 | Level 1 | Level : Level 1 | E | Mechanical Return Air 1
567129 | 1EC1 | Level 1 | Level : Level 1 | E | Mechanical Return Air 1
567090 | 1E29 | Level 1 | Level : Level 1 | E | Mechanical Return Air 1
566944 | 1C09 | Level 1 | Level : Level 1 | D | Mechanical Return Air 1
566911 | 1A06 | Level 1 | Level : Level 1 | E | Mechanical Return Air 1
568948 | 2B16 | Level 2 | Level : Level 2 | E | Mechanical Return Air 2
567008 | 1D38 | Level 1 | Level : Level 1 | E | Mechanical Return Air 1
568941 | 2D15 | Level 2 | Level : Level 2 | E | Mechanical Return Air 2
567031 | 1DC6 | Level 1 | Level : Level 1 | E | Mechanical Return Air 1
568943 | 2D19 | Level 2 | Level : Level 2 | E | Mechanical Return Air 2
568965 | 2D06 | Level 2 | Level : Level 2 | E | Mechanical Return Air 2
568949 | 2B21 | Level 2 | Level : Level 2 | E | Mechanical Return Air 2
568954 | 2B01 | Level 2 | Level : Level 2 | E | Mechanical Return Air 2
568933 | 2C19 | Level 2 | Level : Level 2 | A | Mechanical Return Air 2
568951 | 2B23 | Level 2 | Level : Level 2 | E | Mechanical Return Air 2
568937 | 2D10 | Level 2 | Level : Level 2 | E | Mechanical Return Air 2

# IfcFlowTerminal: 350 x 350 Face 300 x 300 Connection 3 (21)
Type - ElementType: 350 x 350 Face 300 x 300 Connection 3
PSet_Revit_Constraints - Offset: 2.8 m
PSet_Revit_Mechanical - Airflow - Pressure Drop: 4.2672; Flow: 8.29895
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - UpArrow: yes; RightArrow: yes; LeftArrow: yes; DownArrow: yes; System Type: Return Air
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles
PSet_Revit_Type_Dimensions - Duct Width: 0.984252; Duct Height: 0.984252; Diffuser Width: 0.35 m; Diffuser Height: 0.35 m
PSet_Revit_Type_Other - Width 1: 0.2275 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Return Diffuser:350 x 350 Face 300 x 300 Connection 3:350 x 350 Face 300 x 300 Connection 3:...) | In | Mark = TagNumber | Level | Host | System Name
567238 | 1D23 | F | Level 1 | Level : Level 1 | Mechanical Return Air 1
567205 | 1C18 | F | Level 1 | Level : Level 1 | Mechanical Return Air 1
568117 | 1C18 | F | Level 1 | Level : Level 1 | Mechanical Return Air 1
567074 | 1E06 | A | Level 1 | Level : Level 1 | Mechanical Return Air 1
567096 | 1E26 | F | Level 1 | Level : Level 1 | Mechanical Return Air 1
566965 | 1D21 | F | Level 1 | Level : Level 1 | Mechanical Return Air 1
566933 | 1AC2 | F | Level 1 | Level : Level 1 | Mechanical Return Air 1
568940 | 2D14 | F | Level 2 | Level : Level 2 | Mechanical Return Air 2
568946 | 2BC2 | F | Level 2 | Level : Level 2 | Mechanical Return Air 2
568915 | 2C04 | G | Level 2 | Level : Level 2 | Mechanical Return Air 2
568921 | 2A05 | F | Level 2 | Level : Level 2 | Mechanical Return Air 2
568919 | 2A07 | F | Level 2 | Level : Level 2 | Mechanical Return Air 2
568920 | 2A06 | F | Level 2 | Level : Level 2 | Mechanical Return Air 2
568969 | 2D04 | F | Level 2 | Level : Level 2 | Mechanical Return Air 2
568917 | 2A09 | F | Level 2 | Level : Level 2 | Mechanical Return Air 2
568955 | 2B3 | F | Level 2 | Level : Level 2 | Mechanical Return Air 2
568922 | 2A04 | F | Level 2 | Level : Level 2 | Mechanical Return Air 2
568916 | 2C02 | F | Level 2 | Level : Level 2 | Mechanical Return Air 2
568918 | 2A08 | F | Level 2 | Level : Level 2 | Mechanical Return Air 2
568923 | 2A03 | F | Level 2 | Level : Level 2 | Mechanical Return Air 2
568926 | 2A14 | G | Level 2 | Level : Level 2 | Mechanical Return Air 2

# IfcFlowTerminal: 400 x 400 Face 300 x 300 Connection 3 (14)
Type - ElementType: 400 x 400 Face 300 x 300 Connection 3
PSet_Revit_Mechanical - Airflow - Pressure Drop: 4.2672; Flow: 8.29895
PSet_Revit_Constraints - Offset: 2.8 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - UpArrow: yes; RightArrow: yes; LeftArrow: yes; DownArrow: yes; System Type: Return Air
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - Width 1: 0.26 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles
PSet_Revit_Type_Dimensions - Duct Width: 0.984252; Duct Height: 0.984252; Diffuser Width: 0.4 m; Diffuser Height: 0.4 m
Name (M_Return Diffuser:400 x 400 Face 300 x 300 Connection 3:400 x 400 Face 300 x 300 Connection 3:...) | In | Level | Host | System Name | Mark = TagNumber
567187 | 1D16 | Level 1 | Level : Level 1 | Mechanical Return Air 1 | G
567232 | 1D22 | Level 1 | Level : Level 1 | Mechanical Return Air 1 | G
567237 | 1D25 | Level 1 | Level : Level 1 | Mechanical Return Air 1 | G
567267 | 1D25 | Level 1 | Level : Level 1 | Mechanical Return Air 1 | G
568967 | 2DC2 | Level 2 | Level : Level 2 | Mechanical Return Air 2 | G
566928 | 1CC1 | Level 1 | Level : Level 1 | Mechanical Return Air 1 | G
566970 | 1D16 | Level 1 | Level : Level 1 | Mechanical Return Air 1 | G
568945 | 2D21 | Level 2 | Level : Level 2 | Mechanical Return Air 2 | G
568914 | 2C06 | Level 2 | Level : Level 2 | Mechanical Return Air 2 | G
568928 | 2AC1 | Level 2 | Level : Level 2 | Mechanical Return Air 2 | G
568913 | 2C09 | Level 2 | Level : Level 2 | Mechanical Return Air 2 | G
568927 | 2A11 | Level 2 | Level : Level 2 | Mechanical Return Air 2 | G
568912 | 2C14 | Level 2 | Level : Level 2 | Mechanical Return Air 2 | G
568930 | 2C03 | Level 2 | Level : Level 2 | Mechanical Return Air 2 | A

# IfcFlowTerminal: 400mm (3)
Type - ElementType: 400mm
PSet_Revit_Mechanical - Airflow - Pressure Drop: 1.524; Flow: 8.29895
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: A; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air
PSet_Revit_Identity Data - Mark: A
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles
PSet_Revit_Type_Other - Half Height: 0.15 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - Airflow - Min Flow: 1130.07; Max Flow: 5297.2
PSet_Revit_Type_Dimensions - Width: 0.4 m; Height: 0.3 m; Duct Width: 1.31234; Duct Height: 0.984252
Name (M_Supply Diffuser - Sidewall:400mm:400mm:...) | In | Level | Host | Offset (m) | System Name
1116661 | 2BC1 | Level 2 | Level : Level 2 | 3.3595 | Mechanical Supply Air 2
1089954 | Level 1 | Level 1 | Level : Level 1 | 2.5 | Mechanical Supply Air 1
1116499 | 2AC1 | Level 2 | Level : Level 2 | 2.8 | Mechanical Supply Air 2

# IfcFlowTerminal: 450 x 450 Face 300 x 300 Connection 3 (5)
Type - ElementType: 450 x 450 Face 300 x 300 Connection 3
PSet_Revit_Constraints - Offset: 2.8 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - UpArrow: yes; RightArrow: yes; LeftArrow: yes; DownArrow: yes; System Type: Return Air
PSet_Revit_Mechanical - Airflow - Pressure Drop: 4.2672; Flow: 8.29895
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles
PSet_Revit_Type_Dimensions - Duct Width: 0.984252; Duct Height: 0.984252; Diffuser Width: 0.45 m; Diffuser Height: 0.45 m
PSet_Revit_Type_Other - Width 1: 0.2925 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Return Diffuser:450 x 450 Face 300 x 300 Connection 3:450 x 450 Face 300 x 300 Connection 3:...) | In | Mark = TagNumber | Level | Host | System Name
566975 | 1DC1 | H | Level 1 | Level : Level 1 | Mechanical Return Air 1
567114 | 1E24 | H | Level 1 | Level : Level 1 | Mechanical Return Air 1
566981 | 1E16 | A | Level 1 | Level : Level 1 | Mechanical Return Air 1
567120 | 1E24 | H | Level 1 | Level : Level 1 | Mechanical Return Air 1
568925 | 2A01 | H | Level 2 | Level : Level 2 | Mechanical Return Air 2

# IfcFlowTerminal: 455 mmx455 mm - Public (36)
Type - ElementType: 455 mmx455 mm - Public; PredefinedType: SINK
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Plumbing - Flow Pressure: 16812.2
PSet_Revit_Other - TagNumber: P6150M; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Host: Linked Revit Model : Clinic_A.rvt
PSet_Revit_Mechanical - System Type: Domestic Cold Water,Domestic Hot Water,Sanitary; System Name: Domestic Cold Water 1,Domestic Hot Water 1,Sanitary 1
PSet_Revit_Type_Mechanical - WFU: 2; HWFU: 3; CWFU: 3
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; Type Mark: P6150M; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories
PSet_Revit_Type_Dimensions - Sink Width: 0.455 m; Sink Length: 0.455 m; Sanitary Radius: 0.0656168; Hot Water Radius: 0.0246063; Hot Water Diameter: 0.0492126; Sanitary Diameter: 0.131234; Sink Depth: 0.203 m; Cold Water Radius: 0.0246063; Cold Water Diameter: 0.0492126
PSet_Revit_Type_Constraints - Default Elevation: 0 m
Name (M_Sink - Island - Single:455 mmx455 mm - Public:455 mmx455 mm - Public:...) | In | Schedule Level | Mark | Elevation (m)
1081824 | 2A06 | Level 1 | 154 | 5.47
1081410 | 2C14 | Level 1 | 146 | 5.47
1081121 | 1E30 | Level 1 | 145 | 0.9
1079387 | 1D28 | Level 2 | 140 | -3.67
1081840 | 2A05 | Level 1 | 155 | 5.47
1080102 | 1B04 | Level 2 | 142 | -3.67
1081712 | 2A07 | Level 1 | 153 | 5.47
1081665 | 2A09 | Level 1 | 151 | 5.47
1083863 | 2A12 | Level 1 | 158 | 5.47
1081690 | 2A08 | Level 1 | 152 | 5.47
1077454 | 1D02 | Level 2 | 131 | -3.67
1077696 | 1D10 | Level 2 | 132 | -3.67
1078558 | 1D38 | Level 2 | 136 | -3.67
1083409 | 2A13 | Level 2 | 156 | 0.9
1081598 | 2C09 | Level 1 | 147 | 5.47
1079898 | 1E04 | Level 2 | 141 | -3.67
1079325 | 1D32 | Level 2 | 139 | -3.67
1076089 | 1D13 | Level 2 | 126 | -3.67
1078367 | 1D35 | Level 2 | 135 | -3.67
1080682 | 1E16 | Level 2 | 144 | -3.67
1081630 | 2C04 | Level 1 | 149 | 5.47
1084132 | 2C12 | Level 1 | 160 | 5.47
1076976 | 1D09 | Level 2 | 130 | -3.67
1077715 | 1D08 | Level 2 | 133 | -3.67
1078629 | 1D34 | Level 2 | 138 | -3.67
1084625 | 2C17 | Level 1 | 161 | 5.47
1078607 | 1D36 | Level 2 | 137 | -3.67
1081614 | 2C06 | Level 1 | 148 | 5.47
1080459 | 1B10 | Level 2 | 143 | -3.67
1076958 | 1D07 | Level 2 | 129 | -3.67
1084700 | 2C17 | Level 1 | 163 | 5.47
1081649 | 2C02 | Level 1 | 150 | 5.47
1076732 | 1D11 |  | 128 | 0
1078122 | 1D31 | Level 2 | 134 | -3.67
1084116 | 2C10 | Level 1 | 159 | 5.47
1084638 | 2C17 | Level 1 | 162 | 5.47

# IfcFlowTerminal: 500 x 500 Face 300 x 300 Connection 2 (5)
Type - ElementType: 500 x 500 Face 300 x 300 Connection 2
PSet_Revit_Constraints - Offset: 2.8 m
PSet_Revit_Mechanical - Airflow - Pressure Drop: 4.2672; Flow: 8.29895
PSet_Revit_Mechanical - UpArrow: yes; RightArrow: yes; LeftArrow: yes; DownArrow: yes; System Type: Return Air
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Dimensions - Duct Width: 0.984252; Duct Height: 0.984252; Diffuser Width: 0.5 m; Diffuser Height: 0.5 m
PSet_Revit_Type_Other - Width 1: 0.325 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles
Name (M_Return Diffuser:500 x 500 Face 300 x 300 Connection 2:500 x 500 Face 300 x 300 Connection 2:...) | In | Level | Host | Mark = TagNumber | System Name
566907 | 1A02 | Level 1 | Level : Level 1 | I | Mechanical Return Air 1
568968 | 2D04-A | Level 2 | Level : Level 2 | J | Mechanical Return Air 2
568944 | 2D20 | Level 2 | Level : Level 2 | I | Mechanical Return Air 2
568966 | 2D18 | Level 2 | Level : Level 2 | J | Mechanical Return Air 2
567003 | 1B13 | Level 1 | Level : Level 1 | F | Mechanical Return Air 1

# IfcFlowTerminal: 510 mmx455 mm (6)
Type - ElementType: 510 mmx455 mm; PredefinedType: SINK
PSet_Revit_Constraints - Offset: 0 m
PSet_Revit_Mechanical - System Type: Domestic Cold Water,Domestic Hot Water,Sanitary
PSet_Revit_Plumbing - Flow Pressure: 16812.2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: P4700; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - WFU: 2; HWFU: 2.25; CWFU: 2.25
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; Type Mark: P4700; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories
PSet_Revit_Type_Dimensions - Sink Width: 0.455 m; Sink Length: 0.51 m; Sink Depth: 0.203 m; Sanitary Radius: 0.0656168; Sanitary Diameter: 0.131234; Hot Water Radius: 0.0246063; Hot Water Diameter: 0.0492126; Faucet Height: 0.346 m; Cold Water Radius: 0.0246063; Cold Water Diameter: 0.0492126
Name (M_Sink - Work:510 mmx455 mm:510 mmx455 mm:...) | In | Level | Host | System Name | Mark
1098322 | 1C03 | Level 1 | Level : Level 1 | Domestic Cold Water 1,Domestic Hot Water 1,Sanitary 1 | 172
1097731 | 1B16 | Level 1 | Level : Level 1 | Domestic Cold Water 1,Domestic Hot Water 1,Default Sanitary (cskender) | 170
1098106 | 1E03 | Level 1 | Level : Level 1 | Domestic Cold Water 1,Domestic Hot Water 1,Sanitary 1 | 171
1099160 | 1A11 | Level 1 | Level : Level 1 | Domestic Cold Water 1,Domestic Hot Water 1,Sanitary 1 | 175
1098534 | 2B20 | Level 2 | Level : Level 2 | Domestic Cold Water 1,Domestic Hot Water 1,Sanitary 1 | 173
1098845 | 2C05 | Level 2 | Level : Level 2 | Domestic Cold Water 1,Domestic Hot Water 1,Sanitary 1 | 174

# IfcFlowTerminal: 535 mmx485 mm - Public (42)
Type - ElementType: 535 mmx485 mm - Public; PredefinedType: SINK
PSet_Revit_Plumbing - Flow Pressure: 16812.2
PSet_Revit_Constraints - Elevation: 0.865 m
PSet_Revit_Other - TagNumber: P3070; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Domestic Cold Water,Domestic Hot Water,Sanitary; System Name: Domestic Cold Water 1,Domestic Hot Water 1,Sanitary 1
PSet_Revit_Type_Constraints - Default Elevation: 0.865 m
PSet_Revit_Type_Other - Half Oval Short Axis Length 1: 0.155825 m; Half Oval Short Axis Length: 0.159 m; Half Oval Long Axis Length 1: 0.199825 m; Half Oval Long Axis Length: 0.203 m; Half Lavatory Length: 0.2675 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Mechanical - WFU: 1; HWFU: 1.5; CWFU: 1.5
PSet_Revit_Type_Dimensions - Sanitary Radius: 0.0524934; Sanitary Diameter: 0.104987; Oval Short Axis Length: 0.318 m; Oval Long Axis Length: 0.406 m; Lavatory Width: 0.485 m; Lavatory Length: 0.535 m; Lavatory Height: 0.152 m; Hot Water Radius: 0.0246063; Hot Water Diameter: 0.0492126; Cold Water Radius: 0.0246063; Cold Water Diameter: 0.0492126
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; Type Mark: P3070; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories
Name (M_Lavatory - Oval:535 mmx485 mm - Public:535 mmx485 mm - Public:...) | In | Host | Schedule Level | Mark
652235 | 2C24 | Linked Revit Model : Clinic_A.rvt | Level 2 | 99
624609 | 1D40 | Linked Revit Model : Clinic_A.rvt | Level 1 | 66
655837 | 2D13 | Linked Revit Model : Clinic_A.rvt | Level 2 | 112
683407 | 1D26 | Linked Revit Model : Clinic_A.rvt | Level 1 | 120
643128 | 1B19 | Linked Revit Model : Clinic_A.rvt | Level 1 | 69
652493 | 2C08 | Linked Revit Model : Clinic_A.rvt | Level 2 | 101
653370 | 2B6 | Grid : 2 | Level 2 | 109
649233 | 2B22 | Linked Revit Model : Clinic_A.rvt | Level 2 | 72
653399 | 2B5 | Linked Revit Model : Clinic_A.rvt | Level 2 | 110
607299 | 1D22 | Linked Revit Model : Clinic_A.rvt | Level 1 | 10
608074 | 1E11 | Linked Revit Model : Clinic_A.rvt | Level 1 | 11
650031 | 2C16 | Linked Revit Model : Clinic_A.rvt | Level 2 | 80
613952 | 1C09 | Linked Revit Model : Clinic_A.rvt | Level 1 | 34
698241 | 2C22 | Linked Revit Model : Clinic_A.rvt | Level 2 | 122
615041 | 1C07 | Linked Revit Model : Clinic_A.rvt | Level 1 | 37
698631 | 2C07 | <not associated> | Level 2 | 123
622232 | 1A13 | Linked Revit Model : Clinic_A.rvt | Level 1 | 65
608287 | 1E10 | Linked Revit Model : Clinic_A.rvt | Level 1 | 13
608175 | 1E09 | Linked Revit Model : Clinic_A.rvt | Level 1 | 12
605118 | 1E01 | Linked Revit Model : Clinic_A.rvt | Level 1 | 1
651709 | 2C23 | <not associated> | Level 2 | 94
621504 | 1A09 | Linked Revit Model : Clinic_A.rvt | Level 1 | 61
619429 | 1D18 | Linked Revit Model : Clinic_A.rvt | Level 1 | 53
613677 | 1C12 | Linked Revit Model : Clinic_A.rvt | Level 1 | 32
614010 | 1C04 | Linked Revit Model : Clinic_A.rvt | Level 1 | 35
618296 | 1D14 | Linked Revit Model : Clinic_A.rvt | Level 1 | 49
613486 | 1C16 | Linked Revit Model : Clinic_A.rvt | Level 1 | 31
614626 | 1C10 | Linked Revit Model : Clinic_A.rvt | Level 1 | 36
621460 | 1A12 | Linked Revit Model : Clinic_A.rvt | Level 1 | 60
615452 | 1D05 | Linked Revit Model : Clinic_A.rvt | Level 1 | 39
618322 | 1D12 | Linked Revit Model : Clinic_A.rvt | Level 1 | 50
621629 | 1A10 | Linked Revit Model : Clinic_A.rvt | Level 1 | 62
612872 | 1B05 | Linked Revit Model : Clinic_A.rvt | Level 1 | 29
612784 | 1B03 | Linked Revit Model : Clinic_A.rvt | Level 1 | 28
611389 | 1B04 | Linked Revit Model : Clinic_A.rvt | Level 1 | 25
615478 | 1D06 | Linked Revit Model : Clinic_A.rvt | Level 1 | 40
608745 | 1E24 | Linked Revit Model : Clinic_A.rvt | Level 1 | 16
609286 | 1E12 | Linked Revit Model : Clinic_A.rvt | Level 1 | 19
617247 | 1D04 | Linked Revit Model : Clinic_A.rvt | Level 1 | 46
610875 | 1B11 | Linked Revit Model : Clinic_A.rvt | Level 1 | 22
611200 | 1B04 | Linked Revit Model : Clinic_A.rvt | Level 1 | 24
612255 | 1B02 | Linked Revit Model : Clinic_A.rvt | Level 1 | 26

# IfcFlowTerminal: 600 x 600 Face 300 x 300 Connection (283)
Type - ElementType: 600 x 600 Face 300 x 300 Connection
PSet_Revit_Constraints - Offset: 2.8 m
PSet_Revit_Mechanical - UpArrow: yes; RightArrow: yes; LeftArrow: yes; DownArrow: yes
PSet_Revit_Other - InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Pressure Drop: 4.2672; Flow: 8.29895
PSet_Revit_Type_Other - Width 1: 0.39 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles
PSet_Revit_Type_Dimensions - Duct Width: 0.984252; Duct Height: 0.984252; Diffuser Width: 0.6 m; Diffuser Height: 0.6 m
Name | In | Level | Host | System Type | System Name | TagNumber = Mark
M_Return Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:570504 | 1DC1 | Level 1 | Level : Level 1 | Return Air | Mechanical Return Air 1 | L
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:569638 | 2B19 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:567752 | 1D37 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:567809 | 1D33 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568255 | 1D13 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:569835 | 2D06 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:567969 | 1A02 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568331 | 1D06 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:569726 | 2DC1 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566648 | 1BC3 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:569654 | 2B15 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566642 | 1BC2 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566692 | 1D24 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566589 | 1D07 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566691 | 1E14 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568819 | 2A04 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566584 | 1D10 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566649 | 1BC4 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566653 | 1E01 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | F
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566696 | 1C01 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566586 | 1DC1 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566654 | 1E04 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566656 | 1EC1 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566693 | 1DC7 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566657 | 1E29 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566641 | 1B19 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566706 | 1D38 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | F
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566644 | 1B08 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566580 | 1D05 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | G
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566688 | 1E16 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566554 | 1C08 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566579 | 1C07 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566581 | 1DC3 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566588 | 1DC1 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566640 | 1B19 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566643 | 1B06 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566633 | 1B04 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | D
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566646 | 1B12 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568832 | 2CC2 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566655 | 1BC4 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566660 | 1E26 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568865 | 2B10 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566637 | 1B04 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | D
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566631 | 1BC1 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566697 | 1CC1 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566553 | 1C09 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568864 | 2BC6 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566682 | 1E18 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566590 | 1C10 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566704 | 1D34 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566652 | 1E05 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566582 | 1D02 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Return Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568518 | 1DC1 | Level 1 | Level : Level 1 | Return Air | Mechanical Return Air 1 | L
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566572 | 1A02 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568814 | 2A09 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568857 | 2D04 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568830 | 2AC2 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566632 | 1B03 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566650 | 1D38 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | F
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566545 | 1C14 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566543 | 1C19 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566651 | 1BC4 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566699 | 1DC3 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566694 | 1CC1 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566683 | 1E16 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566635 | 1B09 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566701 | 1D16 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566636 | 1B07 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568817 | 2A06 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566569 | 1AC4 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568820 | 2A03 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566645 | 1B10 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566695 | 1C02 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568804 | 2C16 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | D
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568806 | 2C13 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568818 | 2A05 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568825 | 2A12 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566587 | 1DC1 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566550 | 1C18 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566638 | 1B17 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566690 | 1E14 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566662 | 1E27 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568860 | 2D04 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566630 | 1B01 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566562 | 1A06 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566585 | 1DC1 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566687 | 1E16 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566639 | 1B17 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568824 | 2A13 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568826 | 2AC3 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566634 | 1B04 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | D
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568810 | 2C09 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | D
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566583 | 1D08 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566606 | 1DC1 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566629 | 1BC2 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568863 | 2BC2 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566658 | 1EC2 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566659 | 1E25 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566603 | 1D19 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568805 | 2C14 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568875 | 2B9 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566552 | 1CC3 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566703 | 1D32 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566679 | 1E23 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566544 | 1C16 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566672 | 1E07 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566661 | 1E26 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566622 | 1D40 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568809 | 2CC5 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566548 | 1C17 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566698 | 1D11 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566578 | 1AC3 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566551 | 1C15 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566559 | 1A16 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566700 | 1D12 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566686 | 1E16 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566647 | 1B14 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568815 | 2A08 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568877 | 2BC5 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566670 | 1EC1 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568867 | 2B25 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568878 | 2B23 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566674 | 1E08 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568842 | 2C19 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Return Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568559 | 1B19 | Level 1 | Rectangular Duct : Mitered Elbows / Taps | Return Air | Mechanical Return Air 1 | J
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566689 | 1EC1 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566685 | 1E16 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566608 | 1D27 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568861 | 2D04-A | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566705 | 1D36 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566702 | 1D28 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568909 | 2CC1 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568827 | 2AC3 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568869 | 2B24 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568862 | 2D01 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566671 | 1E06 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568831 | 2C01 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566568 | 1A10 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568868 | 2BC4 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566680 | 1EC4 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566628 | 1B15 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566556 | 1C06 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566564 | 1AC5 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568858 | 2D03 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568836 | 2C03 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568816 | 2A07 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566684 | 1E16 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566675 | 1E11 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568844 | 2C03 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568866 | 2B8 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568812 | 2C04 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | D
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566570 | 1A02 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566561 | 1A07 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568828 | 2A11 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566546 | 1C18 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566668 | 1E24 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566563 | 1A04 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566549 | 1C18 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568870 | 2B01 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566673 | 1E06 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568838 | 2CC1 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568835 | 2C08 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | F
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566605 | 1D15 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566592 | 1D16 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568813 | 2C02 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | D
