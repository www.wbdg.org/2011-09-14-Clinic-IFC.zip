Properties of the parts of a building model (IFC2X3), part 35 of 295

# IfcFlowFitting: Tee - Generic (921)
Name (M_Tee - Generic:Tee - Generic:Tee - Generic:...) | In | Center to End Label | Fitting Outside Radius = Insulation Radius | Angle 1 (deg) | Tick Size | Nominal Radius | Nominal Diameter | Fitting Outside Diameter | Center to End | Angle (deg) | Size | System Type | System Name | Mark | Level | Host | Offset (m)
709018 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8455 | Level 1 | Level : Level 1 | -0.3
1001076 | 1E27 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10121 | Level 1 | Level : Level 1 | 2.985
1049168 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12261 | Level 2 | Level : Level 2 | 2.985
726322 | 1A01 | 0.314351 | 0.130208 | 45 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 135 | 80 mmø-80 mmø-80 mmø | Sanitary | Storm | 9920 | Level 2 | Level : Level 2 | -0.55
1048055 | 2CC1 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12017 | Level 2 | Level : Level 2 | 2.985
658518 | Level 1 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 3709 | Level 1 | Level : Level 1 | 0.6
688261 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6021 | Level 1 | Level : Level 1 | -0.4
1052026 | 2A11 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13025 | Level 2 | Level : Level 2 | 2.985
1026710 | 1DC7 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11165 | Level 1 | Level : Level 1 | 2.985
1027171 | 1B04 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11321 | Level 1 | Level : Level 1 | 2.985
660043 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 3876 | Level 2 | Level : Level 2 | 3.1
685862 | Level 1 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5735 | Level 1 | Level : Level 1 | 0.688244
708101 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8332 | Level 1 | Level : Level 1 | -0.3
665263 | Level 2 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4528 | Level 2 | Level : Level 2 | 0.232932
682301 | Level 1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5345 | Level 1 | Level : Level 1 | 0.371263
721263 | 2D16 | 0.616127 | 0.255208 | 45 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 135 | 150 mmø-150 mmø-150 mmø | Sanitary | Default Sanitary (cskender) | 9558 | Level 2 | Level : Level 2 | 4.162
684969 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5626 | Level 1 | Level : Level 1 | -0.4
1051992 | 2A10 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13017 | Level 2 | Level : Level 2 | 2.985
662329 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4193 | Level 2 | Level : Level 2 | 0.2
1000455 | 1BC4 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10081 | Level 1 | Level : Level 1 | 2.985
1013503 | 1C18 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10832 | Level 1 | Level : Level 1 | 2.985
1005117 | 1E19 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10402 | Level 1 | Level : Level 1 | 2.985
693448 | Level 2 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6617 | Level 2 | Level : Level 2 | 0.3
1049120 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12245 | Level 2 | Level : Level 2 | 2.985
1051687 | 2C03 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12949 | Level 2 | Level : Level 2 | 2.985
692787 | 1B04 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6550 | Level 2 | Level : Level 2 | -1.5
662652 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4233 | Level 2 | Level : Level 2 | 0.2
1050400 | 2B19 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12605 | Level 2 | Level : Level 2 | 2.985
1049499 | 2D08 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12373 | Level 2 | Level : Level 2 | 2.985
1052447 | 2A07 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13123 | Level 2 | Level : Level 2 | 2.985
665367 | Level 2 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 4540 | Level 2 | Level : Level 2 | 3.1
680036 | TOF Footing | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5085 | Level 1 | Level : Level 1 | -0.4
712208 | Level 2 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8839 | Level 2 | Level : Level 2 | 0.3
680460 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5142 | Level 1 | Level : Level 1 | -0.4
689188 | Level 1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6154 | Level 1 | Level : Level 1 | 0.5
578060 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.164042 | 0.328084 | 0.09375 | 0.0885417 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 137 | Level 1 | Level : Level 1 | -0.5
661096 | Level 2 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 4009 | Level 2 | Level : Level 2 | 0.2
702146 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7578 | Level 1 | Level : Level 1 | -0.3
638349 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2124 | Level 1 | Level : Level 1 | -0.501123
1050748 | 2BC2 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12709 | Level 2 | Level : Level 2 | 2.98499
1008256 | 1DC1 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10471 | Level 1 | Level : Level 1 | 2.985
687195 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5884 | Level 1 | Level : Level 1 | -0.4
1110885 | 1CC3 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 15040 | Level 1 | Level : Level 1 | 2.985
1049793 | 2D18 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12437 | Level 2 | Level : Level 2 | 2.985
1048927 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12173 | Level 2 | Level : Level 2 | 2.985
577335 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.164042 | 0.328084 | 0.09375 | 0.0885417 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 26 | Level 1 | Level : Level 1 | -0.5
699440 | 1D16 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 7303 | Level 2 | Level : Level 2 | -1.6882
692979 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6580 | Level 2 | Level : Level 2 | 0.2
1027945 | 1DC6 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11561 | Level 1 | Level : Level 1 | 2.985
686497 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5799 | Level 1 | Level : Level 1 | -0.4
719402 | 1A05 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9513 | Level 2 | Level : Level 2 | -1.45
648291 | 1C16 | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Sanitary | Sanitary 1 | 3267 | Level 1 | Level : Level 1 | 0
633397 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1419 | Level 1 | Level : Level 1 | -0.5
1002986 | 1A09 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10299 | Level 1 | Level : Level 1 | 2.985
662455 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4210 | Level 2 | Level : Level 2 | 0.2
1048945 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12181 | Level 2 | Level : Level 2 | 2.985
1028629 | 1C13 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11682 | Level 1 | Level : Level 1 | 2.985
1049201 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12277 | Level 2 | Level : Level 2 | 2.985
1006329 | 1DC6 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10414 | Level 1 | Level : Level 1 | 2.985
644190 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2820 | Level 1 | Level : Level 1 | -0.3
1027221 | 1B07 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11341 | Level 1 | Level : Level 1 | 2.985
647481 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3194 | Level 1 | Level : Level 1 | -0.5
708025 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8317 | Level 1 | Level : Level 1 | -0.3
640413 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2365 | Level 1 | Level : Level 1 | -0.5
1049362 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12341 | Level 2 | Level : Level 2 | 2.985
719657 | 1DC3 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9531 | Level 2 | Level : Level 2 | -1.4
701082 | Level 1 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7468 | Level 1 | Level : Level 1 | 0.2
686390 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5785 | Level 1 | Level : Level 1 | -0.4
662264 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4183 | Level 1 | Level : Level 1 | -0.5
1051873 | 2AC2 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12989 | Level 2 | Level : Level 2 | 2.985
692434 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6515 | Level 2 | Level : Level 2 | 0.2
659113 | 2C12 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 3775 | Level 2 | Level : Level 2 | 2.9
1012892 | 1DC1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10616 | Level 1 | Level : Level 1 | 2.985
643618 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2750 | Level 1 | Level : Level 1 | -0.5
714670 | 1DC3 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9076 | Level 2 | Level : Level 2 | -1.4
638170 | TOF Footing | 0.213542 | 0.171875 | 89.9997 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90.0003 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2117 | Level 1 | Level : Level 1 | -0.501123
1050376 | 2BC4 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12597 | Level 2 | Level : Level 2 | 2.985
698836 | 1DC3 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7217 | Level 2 | Level : Level 2 | -1.5
690022 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6237 | Level 1 | Level : Level 1 | -0.4
665876 | 1D02 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4563 | Level 2 | Level : Level 2 | -1.6882
1049424 | 2D06 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12357 | Level 2 | Level : Level 2 | 2.985
637526 | TOF Footing | 0.213542 | 0.171875 | 89.7201 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 89.7201 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2035 | Level 1 | Level : Level 1 | -0.501123
1027855 | 1A05 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11533 | Level 1 | Level : Level 1 | 2.985
640546 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2382 | Level 1 | Level : Level 1 | -0.5
643063 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 2669 | Level 1 | Level : Level 1 | -0.5
637571 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2042 | Level 1 | Level : Level 1 | -0.501123
1080914 | Level 1 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 14242 | Level 1 | Level : Level 1 | 0.2
683992 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5494 | Level 1 | Level : Level 1 | -0.4
662124 | 1A16 | 0.314351 | 0.130208 | 45 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 135 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 4161 | Level 2 | Level : Level 2 | -1.6882
1027066 | 1B19 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11289 | Level 1 | Level : Level 1 | 2.985
1110931 | 1CC3 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 15048 | Level 1 | Level : Level 1 | 2.985
1077561 | Level 1 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 13961 | Level 1 | Level : Level 1 | 0.2
1050134 | 2BC3 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12529 | Level 2 | Level : Level 2 | 2.985
664959 | Level 2 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4480 | Level 2 | Level : Level 2 | 0.232932
661377 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4052 | Level 2 | Level : Level 2 | 2.9
1012867 | 1DC1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10604 | Level 1 | Level : Level 1 | 2.985
1001502 | 1BC4 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10156 | Level 1 | Level : Level 1 | 2.985
711259 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8730 | Level 1 | Level : Level 1 | -0.3
1013863 | 1C07 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10940 | Level 1 | Level : Level 1 | 2.985
1013934 | 1D06 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10960 | Level 1 | Level : Level 1 | 2.985
1024021 | Level 1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11061 | Level 1 | Level : Level 1 | 2.985
1052497 | 2A05 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13139 | Level 2 | Level : Level 2 | 2.985
1013124 | 1D20 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10708 | Level 1 | Level : Level 1 | 2.985
683528 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 5421 | Level 1 | Level : Level 1 | -0.5
1050077 | 2BC2 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12505 | Level 2 | Level : Level 2 | 2.985
705547 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8014 | Level 1 | Level : Level 1 | -0.3
642629 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2617 | Level 1 | Level : Level 1 | -0.5
1007916 | 1C17 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10435 | Level 1 | Level : Level 1 | 2.985
701853 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7553 | Level 1 | Level : Level 1 | -0.3
1052953 | 2D21 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13267 | Level 2 | Level : Level 2 | 2.985
682677 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5373 | Level 1 | Level : Level 1 | -0.4
633207 | TOF Footing | 0.269224 | 0.130208 | 51.6208 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 128.379 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 1399 | Level 1 | Level : Level 1 | -0.5
1007980 | 1AC3 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10441 | Level 1 | Level : Level 1 | 2.985
1050096 | 2BC3 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12513 | Level 2 | Level : Level 2 | 2.985
1049862 | 2D13 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12453 | Level 2 | Level : Level 2 | 2.985
634444 | Level 1 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Default Sanitary (cskender) | 1577 | Level 1 | Level : Level 1 | 0
709614 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8523 | Level 1 | Level : Level 1 | -0.3
1052639 | 2AC3 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13171 | Level 2 | Level : Level 2 | 2.985
644936 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2876 | Level 1 | Level : Level 1 | -0.501123
1050562 | 2D21 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12653 | Level 2 | Level : Level 2 | 2.985
1012993 | 1DC1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10648 | Level 1 | Level : Level 1 | 2.985
637266 | TOF Footing | 0.335637 | 0.171875 | 54.2327 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 54.2327 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1998 | Level 1 | Level : Level 1 | -0.501123
1026617 | 1E06 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11137 | Level 1 | Level : Level 1 | 2.985
1028504 | 1DC3 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11637 | Level 1 | Level : Level 1 | 2.985
1051418 | 2B11 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12885 | Level 2 | Level : Level 2 | 2.98518
684426 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5544 | Level 1 | Level : Level 1 | -0.4
642724 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Default Sanitary (cskender) | 2625 | Level 1 | Level : Level 1 | -0.5
661110 | Level 2 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 4010 | Level 2 | Level : Level 2 | 0.5
700935 | TOF Footing | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7458 | Level 1 | Level : Level 1 | -0.4
658207 | Level 1 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3668 | Level 2 | Level : Level 2 | -1.6882
697702 | Level 1 | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7080 | Level 2 | Level : Level 2 | -1.5
658324 | 1D20 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3679 | Level 2 | Level : Level 2 | -1.6882
1012638 | 1D26 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10532 | Level 1 | Level : Level 1 | 2.985
1013094 | 1DC1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10692 | Level 1 | Level : Level 1 | 2.985
717723 | 1C07 | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9369 | Level 2 | Level : Level 2 | -1.4
647706 | 1A13 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 3222 | Level 1 | Level : Level 1 | 0
708535 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8391 | Level 1 | Level : Level 1 | -0.3
1012922 | 1DC1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10632 | Level 1 | Level : Level 1 | 2.985
1050588 | 2D21 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12661 | Level 2 | Level : Level 2 | 2.985
1012582 | 1D25 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10520 | Level 1 | Level : Level 1 | 2.985
705165 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7961 | Level 1 | Level : Level 1 | -0.25
644762 | Level 1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 2853 | Level 1 | Level : Level 1 | 3
658564 | Level 1 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 3719 | Level 2 | Level : Level 2 | -1.4
665296 | 1D02 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 4532 | Level 2 | Level : Level 2 | -1.6882
693080 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6596 | Level 1 | Level : Level 1 | -0.4
1052983 | 2BC2 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13283 | Level 2 | Level : Level 2 | 2.985
694291 | 1C13 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6694 | Level 2 | Level : Level 2 | -1.5
683651 | Level 1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5455 | Level 1 | Level : Level 1 | 0.371263
1052800 | 2C05 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13215 | Level 2 | Level : Level 2 | 2.985
642803 | Level 1 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Default Sanitary (cskender) | 2651 | Level 1 | Level : Level 1 | 0
1118143 | 1C02 | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 15146 | Level 2 | Level : Level 2 | -1.4
1048284 | 2C19 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12073 | Level 2 | Level : Level 2 | 2.985
703712 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7803 | Level 1 | Level : Level 1 | -0.3
1050429 | 2B17 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12613 | Level 2 | Level : Level 2 | 2.985
704002 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7838 | Level 1 | Level : Level 1 | -0.3
1052709 | 2AC3 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13187 | Level 2 | Level : Level 2 | 2.985
709096 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8474 | Level 1 | Level : Level 1 | -0.3
1051402 | E1 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12877 | Level 2 | Level : Level 2 | 2.98518
1013817 | 1AC3 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10924 | Level 1 | Level : Level 1 | 2.985
704910 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7913 | Level 1 | Level : Level 1 | -0.3
1013802 | 1CC1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10916 | Level 1 | Level : Level 1 | 2.985
1051840 | 2C24 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12981 | Level 2 | Level : Level 2 | 2.985
696322 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6905 | Level 2 | Level : Level 2 | 0.2
635040 | TOF Footing | 0.314351 | 0.130208 | 45 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 135 | 80 mmø-80 mmø-80 mmø | Sanitary | Default Sanitary (cskender) | 1684 | Level 1 | Level : Level 1 | -0.5
695374 | 1C07 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6811 | Level 2 | Level : Level 2 | -1.5
1053921 | 2D05 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13385 | Level 2 | Level : Level 2 | 2.985
637627 | TOF Footing | 0.320704 | 0.171875 | 56.3764 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 123.624 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2051 | Level 1 | Level : Level 1 | -0.501123
712684 | 1B03 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8865 | Level 2 | Level : Level 2 | -1.4
1013313 | 1D16 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10776 | Level 1 | Level : Level 1 | 2.985
661763 | Level 2 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 4107 | Level 2 | Level : Level 2 | 2.9
647415 | 1A16 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 3182 | Level 1 | Level : Level 1 | 2.9
661864 | 1C07 | 0.314351 | 0.130208 | 45 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 45 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 4116 | Level 2 | Level : Level 2 | -1.6882
694994 | 1C10 | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6752 | Level 2 | Level : Level 2 | -1.5
1051740 | 2AC2 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12957 | Level 2 | Level : Level 2 | 2.985
636677 | TOF Footing | 0.41543 | 0.171875 | 44.9525 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 44.9525 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1927 | Level 1 | Level : Level 1 | -0.5
1047861 | 2CC4 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11977 | Level 2 | Level : Level 2 | 2.985
634425 | Level 1 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Default Sanitary (cskender) | 1569 | Level 1 | Level : Level 1 | 0
1028056 | 1D08 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11605 | Level 1 | Level : Level 1 | 2.985
637863 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2088 | Level 1 | Level : Level 1 | -0.501123
633837 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1472 | Level 1 | Level : Level 1 | -0.5
687647 | Level 1 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Cold Water | Domestic Cold Water 1 | 5941 | Level 1 | Level : Level 1 | 0.6
1050176 | 2B20 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12541 | Level 2 | Level : Level 2 | 2.985
701420 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7507 | Level 1 | Level : Level 1 | -0.3
645354 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2895 | Level 1 | Level : Level 1 | -0.501123
637809 | Level 1 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2083 | Level 1 | Level : Level 1 | 0
1027803 | 1A10 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11517 | Level 1 | Level : Level 1 | 2.985
714299 | 1D10 | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9036 | Level 2 | Level : Level 2 | -1.4
662071 | Level 1 | 0.314351 | 0.130208 | 45 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 135 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 4147 | Level 2 | Level : Level 2 | -1.6882
1027337 | 1BC4 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11369 | Level 1 | Level : Level 1 | 2.985
640317 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2347 | Level 1 | Level : Level 1 | -0.5
1013023 | 1DC1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10664 | Level 1 | Level : Level 1 | 2.985
660278 | 1DC4 | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3900 | Level 2 | Level : Level 2 | -1.6882
633885 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1484 | Level 1 | Level : Level 1 | -0.5
665449 | Level 2 | 0.163462 | 0.0677083 | 45 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 45 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 4548 | Level 2 | Level : Level 2 | 3.1
1028041 | 1D10 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11597 | Level 1 | Level : Level 1 | 2.985
1050975 | 2BC5 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12773 | Level 2 | Level : Level 2 | 2.985
716754 | 1C01 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9265 | Level 2 | Level : Level 2 | -1.4
643526 | 1B19 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Default Sanitary (cskender) | 2735 | Level 1 | Level : Level 1 | 2.9
637907 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2091 | Level 1 | Level : Level 1 | -0.501123
705412 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7998 | Level 1 | Level : Level 1 | -0.25
696363 | 1D05 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6912 | Level 2 | Level : Level 2 | -1.5
1026930 | 1B16 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11233 | Level 1 | Level : Level 1 | 2.985
634736 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Default Sanitary (cskender) | 1628 | Level 1 | Level : Level 1 | -0.3
1013349 | 1CC1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10788 | Level 1 | Level : Level 1 | 2.985
1023371 | 1BC4 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 11057 | Level 1 | Level : Level 1 | 2.985
1081007 | TOF Footing | 0.0677083 | 0.0260417 | 90 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0520833 | 0.0677083 | 90 | 15 mmø-15 mmø-15 mmø | Domestic Hot Water | Domestic Hot Water 1 | 14248 | Level 1 | Level : Level 1 | -0.35
643587 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2741 | Level 1 | Level : Level 1 | -0.5
1002716 | 1C06 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10278 | Level 1 | Level : Level 1 | 2.985
1053062 | 2BC5 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13315 | Level 2 | Level : Level 2 | 2.985
636882 | TOF Footing | 0.415411 | 0.171875 | 44.9543 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 44.9543 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1955 | Level 1 | Level : Level 1 | -0.5
699002 | 1C07 | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7267 | Level 2 | Level : Level 2 | -1.5
725453 | 1B01 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Storm | 9860 | Level 2 | Level : Level 2 | -0.444
1047898 | 2CC3 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11985 | Level 2 | Level : Level 2 | 2.985
702627 | TOF Footing | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7656 | Level 1 | Level : Level 1 | -0.3
1013995 | 1E10 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10992 | Level 1 | Level : Level 1 | 2.985
714475 | 1D10 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9052 | Level 2 | Level : Level 2 | -1.4
643559 | TOF Footing | 0.213758 | 0.0885417 | 45 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 45 | 50 mmø-50 mmø-50 mmø | Sanitary | Default Sanitary (cskender) | 2738 | Level 1 | Level : Level 1 | -0.5
711180 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8718 | Level 1 | Level : Level 1 | -0.3
637708 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 135 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2071 | Level 1 | Level : Level 1 | -0.501123
1049329 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12325 | Level 2 | Level : Level 2 | 2.985
633747 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1470 | Level 1 | Level : Level 1 | -0.5
1002503 | 1AC2 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10257 | Level 1 | Level : Level 1 | 2.985
1048250 | 2C19 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12065 | Level 2 | Level : Level 2 | 2.985
641235 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 2435 | Level 1 | Level : Level 1 | -0.5
702217 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7590 | Level 1 | Level : Level 1 | -0.3
1028474 | 1DC3 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11621 | Level 1 | Level : Level 1 | 2.985
1085684 | 1D02 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 14632 | Level 2 | Level : Level 2 | -1.6882
689546 | TOF Footing | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6182 | Level 1 | Level : Level 1 | -0.4
1048912 | 2D05 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12165 | Level 2 | Level : Level 2 | 2.985
716628 | Level 1 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9258 | Level 2 | Level : Level 2 | -1.4
1022968 | 1B04 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11056 | Level 1 | Level : Level 1 | 2.985
661439 | 1CC1 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 4056 | Level 2 | Level : Level 2 | -1.6882
1013298 | 1D16 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10768 | Level 1 | Level : Level 1 | 2.985
718877 | 1A11 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9453 | Level 2 | Level : Level 2 | -1.4
1013078 | 1DC1 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10684 | Level 1 | Level : Level 1 | 2.985
710383 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8607 | Level 1 | Level : Level 1 | -0.3
641193 | TOF Footing | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Sanitary | Sanitary 1 | 2426 | Level 1 | Level : Level 1 | -0.5
1008118 | 1DC1 | 0.296875 | 0.255208 | 90 | 0.204167 | 0.246063 | 0.492126 | 0.510417 | 0.296875 | 90 | 150 mmø-150 mmø-150 mmø | Fire Protection Wet | Fire Protection | 10451 | Level 1 | Level : Level 1 | 2.985
1026791 | 1BC4 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11181 | Level 1 | Level : Level 1 | 2.985
1137917 | 1A04 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 15656 | Level 1 | Level : Level 1 | 2.985
700754 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7435 | Level 1 | Level : Level 1 | -0.3
647573 | Level 1 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 3205 | Level 1 | Level : Level 1 | 0.232932
1052385 | 2A09 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13107 | Level 2 | Level : Level 2 | 2.985
696866 | 1A11 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6968 | Level 2 | Level : Level 2 | -1.5
1012821 | 1D24 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10580 | Level 1 | Level : Level 1 | 2.985
707239 | TOF Footing | 0.0677083 | 0.0260417 | 90 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0520833 | 0.0677083 | 90 | 15 mmø-15 mmø-15 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8196 | Level 1 | Level : Level 1 | -0.3
1048214 | 2C18 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12057 | Level 2 | Level : Level 2 | 2.985
1013833 | 1AC3 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10932 | Level 1 | Level : Level 1 | 2.985
715823 | Level 1 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9182 | Level 2 | Level : Level 2 | -1.4
1052418 | 2A08 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13115 | Level 2 | Level : Level 2 | 2.985
997914 | 1CC1 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.131234 | 0.262467 | 0.09375 | 0.0885417 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 9999 | Level 2 | Level : Level 2 | -1.6882
642170 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2561 | Level 1 | Level : Level 1 | -0.5
705757 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 8033 | Level 1 | Level : Level 1 | -0.3
1051158 | 2B12 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12813 | Level 2 | Level : Level 2 | 2.985
1026564 | 1E07 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11117 | Level 1 | Level : Level 1 | 2.985
1002812 | 1A01 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10289 | Level 1 | Level : Level 1 | 2.985
699517 | 1D16 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Cold Water | Domestic Cold Water 1 | 7325 | Level 2 | Level : Level 2 | -1.5
1050316 | 2BC3 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12581 | Level 2 | Level : Level 2 | 2.985
1061790 | Level 1 | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 13462 | Level 2 | Level : Level 2 | -1.6882
1014059 | 1D28 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11024 | Level 1 | Level : Level 1 | 2.985
658850 | 2C19 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 3755 | Level 2 | Level : Level 2 | 2.9
656392 | Level 1 | 0.171875 | 0.130208 | 90 | 0.104167 | 0.131234 | 0.262467 | 0.260417 | 0.171875 | 90 | 80 mmø-80 mmø-80 mmø | Sanitary | Sanitary 1 | 3528 | Level 1 | Level : Level 1 | 0.4
642335 | TOF Footing | 0.213542 | 0.171875 | 90 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 90 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2587 | Level 1 | Level : Level 1 | -0.5
719386 | 1A05 | 0.078125 | 0.0364583 | 90 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0729167 | 0.078125 | 90 | 20 mmø-20 mmø-20 mmø | Domestic Hot Water | Domestic Hot Water 1 | 9509 | Level 2 | Level : Level 2 | -1.45
1026549 | 1E24 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11109 | Level 1 | Level : Level 1 | 2.985
1051044 | 2B6 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12789 | Level 2 | Level : Level 2 | 2.985
662849 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Sanitary | Sanitary 1 | 4251 | Level 1 | Level : Level 1 | -0.3
1053273 | 2A13 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13367 | Level 2 | Level : Level 2 | 2.985
1047788 | 2CC5 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 11961 | Level 2 | Level : Level 2 | 2.985
637393 | TOF Footing | 0.413219 | 0.171875 | 45.1689 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45.1689 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2003 | Level 1 | Level : Level 1 | -0.501123
657996 | 1D27 | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 3653 | Level 2 | Level : Level 2 | -1.4
1002840 | 1A16 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 10290 | Level 1 | Level : Level 1 | 2.985
694818 | 1C02 | 0.151042 | 0.109375 | 90 | 0.0875 | 0.106627 | 0.213255 | 0.21875 | 0.151042 | 90 | 65 mmø-65 mmø-65 mmø | Domestic Cold Water | Domestic Cold Water 1 | 6736 | Level 2 | Level : Level 2 | -1.5
701718 | TOF Footing | 0.0989583 | 0.0572917 | 90 | 0.0458333 | 0.0524934 | 0.104987 | 0.114583 | 0.0989583 | 90 | 32 mmø-32 mmø-32 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7539 | Level 1 | Level : Level 1 | -0.3
636096 | TOF Footing | 0.330808 | 0.171875 | 54.9092 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 54.9092 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 1854 | Level 1 | Level : Level 1 | -0.5
640479 | TOF Footing | 0.414943 | 0.171875 | 45 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 45 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2370 | Level 1 | Level : Level 1 | -0.5
1052725 | 2CC2 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13195 | Level 2 | Level : Level 2 | 2.985
1050880 | 2B25 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12749 | Level 2 | Level : Level 2 | 2.985
1051609 | 2AC1 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12933 | Level 2 | Level : Level 2 | 2.985
1052759 | 2CC2 | 0.109375 | 0.0677083 | 90 | 0.0541667 | 0.0656168 | 0.131234 | 0.135417 | 0.109375 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 13203 | Level 2 | Level : Level 2 | 2.985
1049760 | 2D18 | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0656168 | 0.131234 | 0.09375 | 0.0885417 | 90 | 40 mmø-40 mmø-40 mmø | Fire Protection Wet | Fire Protection | 12429 | Level 2 | Level : Level 2 | 2.985
638093 | TOF Footing | 0.213542 | 0.171875 | 89.9999 | 0.1375 | 0.164042 | 0.328084 | 0.34375 | 0.213542 | 89.9999 | 100 mmø-100 mmø-100 mmø | Sanitary | Sanitary 1 | 2098 | Level 1 | Level : Level 1 | -0.501123
703291 | TOF Footing | 0.0677083 | 0.0260417 | 90 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0520833 | 0.0677083 | 90 | 15 mmø-15 mmø-15 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7743 | Level 1 | Level : Level 1 | -0.3
705314 | TOF Footing | 0.0885417 | 0.046875 | 90 | 0.0375 | 0.0410105 | 0.082021 | 0.09375 | 0.0885417 | 90 | 25 mmø-25 mmø-25 mmø | Domestic Hot Water | Domestic Hot Water 1 | 7986 | Level 1 | Level : Level 1 | -0.25
703589 | TOF Footing | 0.130208 | 0.0885417 | 90 | 0.0708333 | 0.082021 | 0.164042 | 0.177083 | 0.130208 | 90 | 50 mmø-50 mmø-50 mmø | Sanitary | Sanitary 1 | 7785 | Level 1 | Level : Level 1 | -0.5
