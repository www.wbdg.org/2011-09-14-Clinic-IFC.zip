Properties of the parts of a building model (IFC2X3), part 2 of 295

# IfcSpace (526)
Name | In | LongName = Name | Area (m2) = GSA BIM Area (m2) | Perimeter (m) | Unbounded Height (m) | Volume (m3) | Level | Upper Limit | Limit Offset (m) | Base Offset (m) | Category Description | Category Code | CirculationZoneName | FireAlarmZoneName | HistoricPreservationZoneName | LightingZoneName | OccupancyZoneName | VentilationZoneName | Number | OmniClass Table 13 Category | RoomTag
2AC1-B-M | Level 2 | OPEN TO BELOW | 74.3648 | 35.8048 | 4 | 297.463 | Level 2 | Level 2 | 4 | 0 | Other Transitional Circulation Spaces | 13-85 31 99 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2AC1-B-M | 13-85 31 99: Other Transitional Circulation Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 0; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2AC1-B; Room Name: OPEN TO BELOW; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D07-M | Level 1 | INTERACTION STATION | 11.7415 | 13.971 | 4 | 46.9659 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D07-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.70549; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D07; Room Name: INTERACTION STATION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B08-M | Level 1 | CENT. STO. | 8.93651 | 12.256 | 4 | 35.746 | Level 1 | Level 1 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B08-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.57611; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B08; Room Name: CENT. STO.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2AC3-M | Level 2 | CORRIDOR | 26.0213 | 24.5991 | 4 | 104.085 | Level 2 | Level 2 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2AC3-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 24.8968; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.53292; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2AC3; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E18-M | Level 1 | BIOMED MAINT. ADMIN. | 14.3633 | 15.4475 | 4 | 57.4533 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E18-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.15693; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E18; Room Name: BIOMED MAINT. ADMIN.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2CC3-M | Level 2 | CORRIDOR | 16.0843 | 17.455 | 4 | 64.337 | Level 2 | Level 2 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2CC3-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.20364; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2CC3; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E03-M | Level 1 | JAN. CL. | 3.46819 | 8.156 | 4 | 13.8728 | Level 1 | Level 1 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E03-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 11.9817; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E03; Room Name: JAN. CL.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E24-M | Level 1 | RECEIVING / STORAGE | 115.12 | 46.4848 | 4 | 460.48 | Level 1 | Level 1 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E24-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 33.1958; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 16.5979; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 1.93619; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E24; Room Name: RECEIVING / STORAGE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E06-M | Level 1 | TECH. WORK STATION | 35.8771 | 24.412 | 4 | 143.508 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E06-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 3.26268; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E06; Room Name: TECH. WORK STATION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D32-M | Level 1 | INTERACTION STATION | 11.8747 | 14.248 | 4 | 47.4986 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D32-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.75336; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D32; Room Name: INTERACTION STATION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C12-M | Level 2 | DIPC CLEAN | 13.2567 | 17.683 | 4 | 53.027 | Level 2 | Level 2 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C12-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.39599; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C12; Room Name: DIPC CLEAN; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D26-M | Level 1 | TOILET | 4.41123 | 8.616 | 4 | 17.6449 | Level 1 | Level 1 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D26-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 9.36557; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D26; Room Name: TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D14-M | Level 1 | SPECIMEN TOILET | 4.18471 | 8.196 | 4 | 16.7388 | Level 1 | Level 1 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D14-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 9.39128; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D14; Room Name: SPECIMEN TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1DC3-M | Level 1 | CORRIDOR | 29.6548 | 38.2702 | 4 | 118.619 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1DC3-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.18807; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1DC3; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E15-M | Level 1 | CENTRAL MECH. RM. | 27.1573 | 23.4045 | 4 | 108.629 | Level 1 | Level 1 | 4 | 0 | Hazardous Material Storage Space | 13-75 41 24 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E15-M | 13-75 41 24: Hazardous Material Storage Space | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.19703; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E15; Room Name: CENTRAL MECH. RM.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1C17-M | Level 1 | CHIEF AERO MED. | 8.99885 | 12.052 | 4 | 35.9954 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C17-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.42186; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C17; Room Name: CHIEF AERO MED.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1C06-M | Level 1 | SOIL. UTL. / TRASH | 4.6539 | 8.7368 | 4 | 18.6156 | Level 1 | Level 1 | 4 | 0 | Soiled Storage Room Space | 13-75 41 14 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C06-M | 13-75 41 14: Soiled Storage Room Space | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 9.00168; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C06; Room Name: SOIL. UTL. / TRASH; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C11-M | Level 2 | HK | 4.57226 | 8.51662 | 4 | 18.289 | Level 2 | Level 2 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C11-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 8.93151; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C11; Room Name: HK; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D24-M | Level 1 | RECORDS | 10.9544 | 13.279 | 4 | 43.8178 | Level 1 | Level 1 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D24-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.81251; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D24; Room Name: RECORDS; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2A01-M | Level 2 | LIBRARY / CONF. ROOM | 24.9256 | 21.0774 | 4 | 99.7024 | Level 2 | Level 2 | 4 | 0 | Conference Room | 13-11 21 17 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2A01-M | 13-11 21 17: Conference Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.05471; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2A01; Room Name: LIBRARY / CONF. ROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E01-M | Level 1 | HK EQUIP. STORAGE | 8.96611 | 11.996 | 4 | 35.8644 | Level 1 | Level 1 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E01-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.41536; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E01; Room Name: HK EQUIP. STORAGE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E05-M | Level 1 | CHIEF LOG OFFICE | 9.1712 | 12.132 | 4 | 36.6848 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E05-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.343; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E05; Room Name: CHIEF LOG OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E08-M | Level 1 | SUPER | 9.10116 | 12.492 | 4 | 36.4046 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E08-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.58148; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E08; Room Name: SUPER; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D31-M | Level 1 | PEDIATRIC WTS & MSRS | 10.2186 | 13.223 | 4 | 40.8743 | Level 1 | Level 1 | 4 | 0 | Physical Examination Room | 13-41 41 14 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D31-M | 13-41 41 14: Physical Examination Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.20481; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D31; Room Name: PEDIATRIC WTS & MSRS; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B03-M | Level 1 | BLOOD DRAW | 8.90697 | 12.236 | 4 | 35.6279 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B03-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.58716; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B03; Room Name: BLOOD DRAW; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D11-M | Level 2 | CMDR OFFICE | 14.4854 | 15.4299 | 4 | 57.9416 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D11-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.10764; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D11; Room Name: CMDR OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B12-M | Level 1 | CLEAN SUP. & EQUIP. | 3.30216 | 7.87805 | 4 | 13.2086 | Level 1 | Level 1 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B12-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 11.4396; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B12; Room Name: CLEAN SUP. & EQUIP.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B2-M | Level 2 | JAN. CL. | 1.8928 | 5.512 | 4 | 7.5712 | Level 2 | Level 2 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B2-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 0; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B2; Room Name: JAN. CL.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2CC2-M | Level 2 | CORRIDOR | 12.6624 | 13.7632 | 4 | 50.6497 | Level 2 | Level 2 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2CC2-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.21183; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2CC2; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D28-M | Level 1 | INTERACTION STATION | 11.8131 | 13.868 | 4 | 47.2523 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D28-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.62911; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D28; Room Name: INTERACTION STATION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2BC6-M | Level 2 | CORRIDOR | 7.96841 | 12.8099 | 4 | 31.8736 | Level 2 | Level 2 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2BC6-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.70838; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2BC6; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E26-M | Level 1 | WORK ROOM | 18.3456 | 18.218 | 4 | 73.3825 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E26-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.76164; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E26; Room Name: WORK ROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B13-M | Level 2 | ELECTRICAL | 8.90434 | 12.551 | 4 | 35.6173 | Level 2 | Level 2 | 4 | 0 | Electrical Room | 13-81 21 21 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B13-M | 13-81 21 21: Electrical Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.75875; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B13; Room Name: ELECTRICAL; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D23-M | Level 1 | GROUP IS | 17.9179 | 17.522 | 4 | 71.6717 | Level 1 | Level 1 | 4 | 0 | Other Healing Spaces | 13-41 41 99 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D23-M | 13-41 41 99: Other Healing Spaces | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.68905; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D23; Room Name: GROUP IS; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D21-M | Level 2 | LIBRARY / CLASSROOM | 26.4425 | 20.9785 | 4 | 105.77 | Level 2 | Level 2 | 4 | 0 | Classroom | 13-11 11 17 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D21-M | 13-11 11 17: Classroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 3.80417; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D21; Room Name: LIBRARY / CLASSROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E30-M | Level 1 | SOIL. LIN. | 6.20673 | 10.5832 | 4 | 24.8269 | Level 1 | Level 1 | 4 | 0 | Soiled Storage Room Space | 13-75 41 14 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E30-M | 13-75 41 14: Soiled Storage Room Space | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 8.17603; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E30; Room Name: SOIL. LIN.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1A01-M | Level 1 | PATIENT ADMIN. RECEPT. | 19.0169 | 18.7 | 4 | 76.0677 | Level 1 | Level 1 | 4 | 0 | Reception Space | 13-11 11 31 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A01-M | 13-11 11 31: Reception Space | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.71509; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1A01; Room Name: PATIENT ADMIN. RECEPT.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1A09-M | Level 1 | W. TOILET | 9.81779 | 12.7585 | 4 | 39.2712 | Level 1 | Level 1 | 4 | 0 | Restroom | 13-41 11 14 21 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A09-M | 13-41 11 14 21: Restroom | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.23124; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1A09; Room Name: W. TOILET; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2AC2-M | Level 2 | CORRIDOR | 13.9259 | 20.671 | 4 | 55.7034 | Level 2 | Level 2 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 2A | Fire Alarm Zone 2A | Historic Preservation Zone 2A | Lighting Zone 2A | Occupancy Zone 2A | Ventilation Zone 2A | 2AC2-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.11751; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2AC2; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1BC4-M | Level 1 | CORRIDOR | 41.7215 | 44.6228 | 4 | 166.886 | Level 1 | Level 1 | 4 | 0 | Corridor | 13-85 11 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1BC4-M | 13-85 11 11: Corridor | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 33.1958; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.12844; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1BC4; Room Name: CORRIDOR; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1DC1-M | Level 1 | WAITING / ACTIVITY AREA | 178.217 | 77.9761 | 4 | 712.868 | Level 1 | Level 1 | 4 | 0 | Waiting Room | 13-51 31 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1DC1-M | 13-51 31 11: Waiting Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 66.3916; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 24.8968; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 2.09337; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1DC1; Room Name: WAITING / ACTIVITY AREA; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1C07-M | Level 1 | OPT. EXAM / OFF. | 16.303 | 20.2071 | 4 | 65.2119 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1C | Fire Alarm Zone 1C | Historic Preservation Zone 1C | Lighting Zone 1C | Occupancy Zone 1C | Ventilation Zone 1C | 1C07-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.94328; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1C07; Room Name: OPT. EXAM / OFF.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E21-M | Level 1 | FLAMABLE STORAGE | 4.82734 | 9.4192 | 4 | 19.3093 | Level 1 | Level 1 | 4 | 0 | Hazardous Material Storage Space | 13-75 41 24 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E21-M | 13-75 41 24: Hazardous Material Storage Space | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 0; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 9.35611; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E21; Room Name: FLAMABLE STORAGE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B21-M | Level 2 | PH SUPER | 8.43814 | 11.9676 | 4 | 33.7526 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B21-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.8006; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B21; Room Name: PH SUPER; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1A14-M | Level 1 | SUPER / NCOIC | 6.74816 | 10.2982 | 4 | 26.9926 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A14-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 7.31755; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1A14; Room Name: SUPER / NCOIC; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1B09-M | Level 1 | DRESS | 4.12527 | 8.15205 | 4 | 16.5011 | Level 1 | Level 1 | 4 | 0 | Dressing Room | 13-41 11 41 11 | Circulation Zone 1B | Fire Alarm Zone 1B | Historic Preservation Zone 1B | Lighting Zone 1B | Occupancy Zone 1B | Ventilation Zone 1B | 1B09-M | 13-41 11 41 11: Dressing Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 9.47553; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1B09; Room Name: DRESS; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2C13-M | Level 2 | TRASH | 4.98879 | 9.756 | 4 | 19.9552 | Level 2 | Level 2 | 4 | 0 | Soiled Storage Room Space | 13-75 41 14 | Circulation Zone 2C | Fire Alarm Zone 2C | Historic Preservation Zone 2C | Lighting Zone 2C | Occupancy Zone 2C | Ventilation Zone 2C | 2C13-M | 13-75 41 14: Soiled Storage Room Space | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 9.37702; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2C13; Room Name: TRASH; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D15-M | Level 1 | WTS & MEAS. ROOM | 4.57728 | 8.7009 | 4 | 18.3091 | Level 1 | Level 1 | 4 | 0 | Physical Examination Room | 13-41 41 14 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D15-M | 13-41 41 14: Physical Examination Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 9.11477; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D15; Room Name: WTS & MEAS. ROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E16-M | Level 1 | BMET WORK STATION | 47.3986 | 27.475 | 4 | 189.594 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E16-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 49.7937; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 2.77946; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E16; Room Name: BMET WORK STATION; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1A05-M | Level 1 | TRICARE OFFICE | 8.29768 | 11.696 | 4 | 33.1907 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1A | Fire Alarm Zone 1A | Historic Preservation Zone 1A | Lighting Zone 1A | Occupancy Zone 1A | Ventilation Zone 1A | 1A05-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.7588; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1A05; Room Name: TRICARE OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E29-M | Level 1 | HK. SUPV. OFFICE | 9.94955 | 13.136 | 4 | 39.7982 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E29-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 6.33065; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E29; Room Name: HK. SUPV. OFFICE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E11-M | Level 1 | STAFF LOUNGE | 13.6597 | 14.784 | 4 | 54.639 | Level 1 | Level 1 | 4 | 0 | Break Room | 13-51 11 21 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E11-M | 13-51 11 21: Break Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 5.18965; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E11; Room Name: STAFF LOUNGE; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1D16-M | Level 1 | PROVIDER CUBICLES | 65.7954 | 36.289 | 4 | 263.182 | Level 1 | Level 1 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 1D | Fire Alarm Zone 1D | Historic Preservation Zone 1D | Lighting Zone 1D | Occupancy Zone 1D | Ventilation Zone 1D | 1D16-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 41.4947; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 16.5979; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 2.64465; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1D16; Room Name: PROVIDER CUBICLES; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
1E14-M | Level 1 | DISASTER STOR. | 21.1412 | 19.463 | 4 | 84.5649 | Level 1 | Level 1 | 4 | 0 | Storage Room | 13-75 11 11 | Circulation Zone 1E | Fire Alarm Zone 1E | Historic Preservation Zone 1E | Lighting Zone 1E | Occupancy Zone 1E | Ventilation Zone 1E | 1E14-M | 13-75 11 11: Storage Room | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 16.5979; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 4.41437; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 1E14; Room Name: DISASTER STOR.; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2B25-M | Level 2 | SOIL. UTL. / TRASH | 6.7255 | 12.644 | 4 | 26.902 | Level 2 | Level 2 | 4 | 0 | Soiled Storage Room Space | 13-75 41 14 | Circulation Zone 2B | Fire Alarm Zone 2B | Historic Preservation Zone 2B | Lighting Zone 2B | Occupancy Zone 2B | Ventilation Zone 2B | 2B25-M | 13-75 41 14: Soiled Storage Room Space | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 8.29895; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 0; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 9.01464; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2B25; Room Name: SOIL. UTL. / TRASH; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
2D04A-M | Level 2 | COMPUTER ROOM | 32.0805 | 23.4175 | 4 | 128.322 | Level 2 | Level 2 | 4 | 0 | Office | 13-15 11 34 11 | Circulation Zone 2D | Fire Alarm Zone 2D | Historic Preservation Zone 2D | Lighting Zone 2D | Occupancy Zone 2D | Ventilation Zone 2D | 2D04A-M | 13-15 11 34 11: Office | PSet_Revit_Mechanical - Airflow - Specified Supply Airflow: 0; Actual Supply Airflow: 24.8968; Return Airflow: 0; Specified Return Airflow: 0; Actual Return Airflow: 8.29895; Specified Exhaust Airflow: 0; Actual Exhaust Airflow: 0; PSet_Revit_Energy Analysis - Zone: Default; Plenum: no; Occupiable: yes; Condition Type: 2; Space Type: -1; Design Heating Load: 0; Design Cooling Load: 0; PSet_Revit_Electrical - Lighting - Average Estimated Illumination: 0; Room Cavity Ratio: 3.50016; Lighting Calculation Workplane: 0.762 m; Ceiling Reflectance: 0.75; Wall Reflectance: 0.5; Floor Reflectance: 0.2; PSet_Revit_Identity Data - Room Number: 2D04-A; Room Name: COMPUTER ROOM; PSet_Revit_Electrical - Loads - Design HVAC Load per area: 0; Design Other Load per area: 0
