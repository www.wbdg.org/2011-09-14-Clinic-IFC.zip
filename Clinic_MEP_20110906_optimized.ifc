Properties of the parts of a building model (IFC2X3), part 22 of 295

# IfcFlowFitting: Elbow - Generic (2063)
Name (M_Elbow - Generic:Elbow - Generic:Elbow - Generic:...) | In | Level | Host | Offset (m) | Mark | Tick Size | Nominal Radius | Nominal Diameter | Insulation Radius = Fitting Outside Radius | Fitting Outside Diameter | Center to End | Angle (deg) | Size | Center Radius | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | System Type | System Name
1117948 | 1D11 | Level 2 | Level : Level 2 | -1.5 | 15113 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
642031 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 2537 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
662347 | Level 2 | Level 2 | Level : Level 2 | 2.9 | 4194 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
694181 | 1C18 | Level 2 | Level : Level 2 | -1.5 | 6677 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
701130 | 1E10 | Level 1 | Level : Level 1 | 0.2 | 7478 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
633821 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1471 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
686151 | Level 1 | Level 1 | Level : Level 1 | 0.6882 | 5774 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1117852 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 15109 | 0.0468836 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0723937 | 67 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1000285 | 1E15 | Level 1 | Level : Level 1 | 2.985 | 10052 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
707363 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8226 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
694665 | 1D13 | Level 2 | Level : Level 2 | -1.5 | 6723 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
679867 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5079 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
701021 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 7466 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
656091 | 1E12 | Level 2 | Level : Level 2 | -1.6882 | 3511 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
701019 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 7464 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
698592 | Level 1 | Level 2 | Level : Level 2 | -1.5 | 7185 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1013922 | 1D05 | Level 1 | Level : Level 1 | 2.985 | 10954 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
635153 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 1717 | 0.0541826 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885677 | 90.0169 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
1026640 | 1D36 | Level 1 | Level : Level 1 | 2.985 | 11143 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
639882 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 2293 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
711084 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8694 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
711626 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8770 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
636562 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1907 | 0.0295326 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0456019 | 45.2656 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1068886 | 1D25 | Level 2 | Level : Level 2 | -1.67 | 13646 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Supply | Hydronic Supply 1
682686 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5377 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
698970 | Level 2 | Level 2 | Level : Level 2 | 0.688244 | 7255 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
696877 | 1A16 | Level 2 | Level : Level 2 | -1.5 | 6972 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1078824 | 1D38 | Level 1 | Level : Level 1 | 0.371263 | 14057 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
702480 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7643 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
643502 | Level 1 | Level 1 | Level : Level 1 | 2.9 | 2734 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
687038 | Level 1 | Level 1 | Level : Level 1 | 0.806263 | 5873 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1049242 | 2DC2 | Level 2 | Level : Level 2 | 2.985 | 12287 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
659118 | 1D13 | Level 2 | Level : Level 2 | -1.4 | 3779 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
665760 | Level 2 | Level 2 | Level : Level 2 | 3.1 | 4559 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
637585 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 2045 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
708013 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8314 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
715279 | 1D10 | Level 2 | Level : Level 2 | -1.4 | 9121 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
698759 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 7202 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
657265 | 1B04 | Level 1 | Level : Level 1 | 3.1 | 3618 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
685550 | Level 1 | Level 1 | Level : Level 1 | 0.806263 | 5685 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1067941 | Level 1 | Level 2 | Level : Level 2 | -1.67 | 13566 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Return | Hydronic Return 1
721694 | Level 1 | Level 2 | Level : Level 2 | -4.27 | 9593 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Undefined
1081270 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 14267 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
696266 | Level 1 | Level 2 | Level : Level 2 | -1.5 | 6900 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1022553 | 1BC2 | Level 1 | Level : Level 1 | 2.985 | 11055 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
715231 | 1D08 | Level 1 | Level : Level 1 | 3.17 | 9111 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
708544 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8395 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1004859 | 1E27 | Level 1 | Level : Level 1 | 2.985 | 10323 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
714662 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 9075 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
717145 | 1C02 | Level 2 | Level : Level 2 | -1.4 | 9314 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
692656 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 6530 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1050355 | 2B23 | Level 2 | Level : Level 2 | 2.985 | 12591 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
663270 | Level 1 | Level 1 | Level : Level 1 | 0 | 4309 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1080912 | 1E16 | Level 1 | Level : Level 1 | 0.2 | 14240 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
685553 | 1D18 | Level 1 | Level : Level 1 | 0.806263 | 5688 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
637222 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 1991 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
717641 | 1D07 | Level 2 | Level : Level 2 | -1.4 | 9364 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
717877 | 1D04 | Level 2 | Level : Level 2 | -1.4 | 9394 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1096326 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 14847 | 0.0166667 | 0.015625 | 0.03125 | 0.0208333 | 0.0416667 | 0.0416667 | 90 | 10 mmø-10 mmø | 0.0416667 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1013649 | 1C19 | Level 1 | Level : Level 1 | 2.985 | 10874 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
724060 | 1C05 | Level 1 | Level : Level 1 | 4.126 | 9748 | 0.0431472 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.0625635 | 45 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Undefined | Default Domestic Cold Water (cskender)
661095 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 4008 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
712191 | Level 2 | Level 2 | Level : Level 2 | 0.3 | 8833 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1003236 | 1E20 | Level 1 | Level : Level 1 | 2.985 | 10310 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
701946 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 7571 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
693022 | 1B11 | Level 2 | Level : Level 2 | -1.5 | 6590 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
698761 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 7204 | 0.0174683 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.0393036 | 79.9581 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
658159 | 1DC4 | Level 2 | Level : Level 2 | -1.6882 | 3664 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
702164 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7583 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1027302 | 1B21 | Level 1 | Level : Level 1 | 2.985 | 11359 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
635064 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 1693 | 0.026142 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0403664 | 40.5146 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
634795 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 1645 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
663345 | 1D27 | Level 2 | Level : Level 2 | -1.4 | 4312 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1063014 | 2D05 | Level 1 | Level : Level 1 | 7.555 | 13516 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1078840 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 14064 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
686066 | Level 1 | Level 1 | Level : Level 1 | 0.688244 | 5766 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1081207 | TOF Footing | Level 1 | Level : Level 1 | -0.35 | 14260 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
680498 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 5149 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
707046 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8156 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
714651 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 9070 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
637524 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 2033 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1082311 | 1CC1 | Level 2 | Level : Level 2 | 0.1 | 14342 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1150912 | 2CS3 | Roof - Main | Level : Roof - Main | -0.444 | 15710 | 0.0375 | 0.131234 | 0.262467 | 0.046875 | 0.09375 | 0.0677083 | 45 | 80 mmø-80 mmø | 0.0677083 |  |  |  |  |  |  | Sanitary | Storm
682613 | Level 1 | Level 1 | Level : Level 1 | 0.806263 | 5365 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
636881 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1954 | 0.0293401 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0453046 | 45 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
706408 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 8094 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1114245 | 2A10 | Level 2 | Level : Level 2 | 2.985 | 15098 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1061427 | Level 1 | Level 2 | Level : Level 2 | -1.4 | 13437 | 0.0875 | 0.106627 | 0.213255 | 0.109375 | 0.21875 | 0.130208 | 90 | 65 mmø-65 mmø | 0.130208 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
719359 | 1A05 | Level 2 | Level : Level 2 | -1.35 | 9498 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
694494 | 1C15 | Level 2 | Level : Level 2 | -1.5 | 6700 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
706792 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8128 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
708596 | Level 1 | Level 1 | Level : Level 1 | 0.5 | 8402 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
682762 | Level 1 | Level 1 | Level : Level 1 | 0.688244 | 5387 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
703846 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 7817 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1085917 | Level 2 | Level 2 | Level : Level 2 | 0.908719 | 14672 | 0.0166667 | 0.0164042 | 0.0328084 | 0.0208333 | 0.0416667 | 0.0416667 | 90 | 10 mmø-10 mmø | 0.0416667 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
700178 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 7385 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1080841 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 14220 | 0.047146 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0770655 | 82.0718 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
703564 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 7784 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
696633 | 1AC3 | Level 2 | Level : Level 2 | -1.5 | 6940 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1013884 | 1C07 | Level 1 | Level : Level 1 | 2.985 | 10946 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
644000 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2779 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
665181 | 1D02 | Level 2 | Level : Level 2 | -1.6882 | 4516 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
641479 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2469 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1082719 | 2A09 | Level 2 | Level : Level 2 | 0.2 | 14375 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1002296 | 1B16 | Level 1 | Level : Level 1 | 2.985 | 10228 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
657868 | 1DC1 | Level 2 | Level : Level 2 | -1.6882 | 3639 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
634162 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1511 | 0.0557709 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0781638 | 44.1556 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
693061 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 6594 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
708487 | 1D05 | Level 1 | Level : Level 1 | 0.2 | 8386 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
704975 | TOF Footing | Level 1 | Level : Level 1 | -0.25 | 7935 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1082561 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 14366 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
722277 | 2D05 | Level 2 | Level : Level 2 | 0.3 | 9637 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Storm
635065 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 1694 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
1012695 | 1D25 | Level 1 | Level : Level 1 | 2.985 | 10546 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
715003 | Level 2 | Level 2 | Level : Level 2 | 0.7 | 9101 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
637423 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 2010 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
636635 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1910 | 0.0293299 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0452889 | 44.9859 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1012603 | 1D25 | Level 1 | Level : Level 1 | 2.985 | 10526 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
687870 | Level 1 | Level 1 | Level : Level 1 | 0.806263 | 5974 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1012880 | 1DC1 | Level 1 | Level : Level 1 | 2.985 | 10610 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
697290 | Level 2 | Level 2 | Level : Level 2 | 0.5 | 7021 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
702632 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 7660 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1123087 | 1E07 | Level 2 | Level : Level 2 | -1.5 | 15210 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
693117 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 6600 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
705524 | TOF Footing | Level 1 | Level : Level 1 | -0.25 | 8006 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1137911 | 1AC5 | Level 1 | Level : Level 1 | 2.985 | 15654 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1049141 | 2D05 | Level 2 | Level : Level 2 | 2.985 | 12251 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
637431 | 1D18 | Level 1 | Level : Level 1 | 0.3 | 2016 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
637950 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 2096 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
683931 | Level 1 | Level 1 | Level : Level 1 | 0.371263 | 5491 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
711169 | 1C10 | Level 1 | Level : Level 1 | 0.2 | 8714 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
709076 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 8467 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
999046 | Level 2 | Level 2 | Level : Level 2 | 3.1 | 10047 | 0.0375 | 0.0656168 | 0.131234 | 0.046875 | 0.09375 | 0.0677083 | 90 | 40 mmø-40 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
696772 | 1A09 | Level 2 | Level : Level 2 | -1.5 | 6955 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1077964 | Level 1 | Level 1 | Level : Level 1 | 0.806263 | 13995 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1117850 | 2C10 | Level 2 | Level : Level 2 | 0.2 | 15107 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1070102 | 2D05 | Level 2 | Level : Level 2 | 3.8 | 13679 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Supply | Hydronic Supply 1
706206 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8074 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
658213 | 1DC4 | Level 2 | Level : Level 2 | -1.6882 | 3669 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
692936 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 6563 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
640111 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 2335 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
644188 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 2818 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
717036 | 1D11 | Level 2 | Level : Level 2 | -1.4 | 9299 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
699463 | 1D16 | Level 2 | Level : Level 2 | -0.5 | 7311 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
684816 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 5600 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1049314 | 2D05 | Level 2 | Level : Level 2 | 2.985 | 12319 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1012398 | 1E29 | Level 1 | Level : Level 1 | 2.985 | 10490 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
639829 | TOF Footing | Level 1 | Level : Level 1 | -0.501123 | 2276 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
708595 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8401 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
715792 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 9178 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1077845 | 1D10 | Level 1 | Level : Level 1 | 0.55 | 13983 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
716018 | 1D16 | Level 2 | Level : Level 2 | -1.4 | 9205 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1062702 | 1BC4 | Level 1 | Level : Level 1 | 2.985 | 13474 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1000303 | 1EC1 | Level 1 | Level : Level 1 | 2.985 | 10057 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1079985 | 1E04 | Level 1 | Level : Level 1 | 0.806263 | 14149 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
698899 | Level 2 | Level 2 | Level : Level 2 | 0.9144 | 7229 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1150822 | 2D05 | Level 2 | Level : Level 2 | 4.236 | 15691 | 0.0375 | 0.164042 | 0.328084 | 0.046875 | 0.09375 | 0.0677083 | 90 | 100 mmø-100 mmø | 0.0677083 |  |  |  |  |  |  | Sanitary | Storm
1000345 | 1BC3 | Level 1 | Level : Level 1 | 2.985 | 10065 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1150864 | 2C14 | Roof - Main | Level : Roof - Main | -0.905 | 15697 | 0.0375 | 0.164042 | 0.328084 | 0.046875 | 0.09375 | 0.0677083 | 90 | 100 mmø-100 mmø | 0.0677083 |  |  |  |  |  |  | Sanitary | Storm
710392 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8611 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
633672 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1464 | 0.0551847 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0773422 | 43.7354 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1067883 | TOF Footing | Level 1 | Level : Level 1 | -0.6 | 13563 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Return | Hydronic Return 1
706730 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 8120 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
635838 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1810 | 0.0220279 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0340137 | 34.5496 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
723150 | 2D05 | Level 2 | Level : Level 2 | 3.775 | 9683 | 0.0569544 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.0798224 | 45 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Storm
644348 | Level 1 | Level 1 | Level : Level 1 | 2.9 | 2827 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
692850 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 6558 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1049663 | 2D18 | Level 2 | Level : Level 2 | 2.985 | 12411 | 0.0375 | 0.0246063 | 0.0492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 15 mmø-15 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
647583 | Level 1 | Level 1 | Level : Level 1 | 2.9 | 3213 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1082051 | 1CC1 | Level 2 | Level : Level 2 | -1.5 | 14315 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1070118 | 2D05 | Level 2 | Level : Level 2 | 4 | 13682 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Return | Hydronic Return 1
698990 | Level 2 | Level 2 | Level : Level 2 | 0.688244 | 7263 | 0.0375 | 0.0410105 | 0.082021 | 0.046875 | 0.09375 | 0.0677083 | 90 | 25 mmø-25 mmø | 0.0677083 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
715334 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 9129 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
635116 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1706 | 0.0293401 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0453046 | 45 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
724093 | Level 1 | Level 1 | Level : Level 1 | 4.126 | 9750 | 0.104167 | 0.131234 | 0.262467 | 0.130208 | 0.260417 | 0.151042 | 90 | 80 mmø-80 mmø | 0.151042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Undefined | Default Domestic Cold Water (cskender)
1086786 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 14740 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
689562 | TOF Footing | Level 1 | Level : Level 1 | -0.4 | 6187 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1000290 | 1EC1 | Level 1 | Level : Level 1 | 2.985 | 10053 | 0.204167 | 0.246063 | 0.492126 | 0.255208 | 0.510417 | 0.276042 | 90 | 150 mmø-150 mmø | 0.276042 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
1077238 | 1D09 | Level 1 | Level : Level 1 | 0.2 | 13929 | 0.0013159 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0025848 | 5.16646 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1012981 | 1D22 | Level 1 | Level : Level 1 | 2.985 | 10642 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Fire Protection Wet | Fire Protection
684711 | Level 1 | Level 1 | Level : Level 1 | 0.806263 | 5584 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
663371 | Level 2 | Level 2 | Level : Level 2 | 2.9 | 4313 | 0.0541667 | 0.0656168 | 0.131234 | 0.0677083 | 0.135417 | 0.0885417 | 90 | 40 mmø-40 mmø | 0.0885417 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1150959 | 2A06 | Roof - Main | Level : Roof - Main | -0.905 | 15716 | 0.0375 | 0.246063 | 0.492126 | 0.046875 | 0.09375 | 0.0677083 | 90 | 150 mmø-150 mmø | 0.0677083 |  |  |  |  |  |  | Sanitary | Storm
636339 | TOF Footing | Level 1 | Level : Level 1 | -0.5 | 1872 | 0.0292319 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.0451375 | 44.8505 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
663512 | 1B07 | Level 2 | Level : Level 2 | -0.2 | 4320 | 0.0708333 | 0.082021 | 0.164042 | 0.0885417 | 0.177083 | 0.109375 | 90 | 50 mmø-50 mmø | 0.109375 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
717780 | Level 2 | Level 2 | Level : Level 2 | 0.2 | 9381 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1085206 | 1D16 | Level 2 | Level : Level 2 | -0.5 | 14625 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1082678 | 2A09 | Level 2 | Level : Level 2 | 0.2 | 14368 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
1070101 | 2D05 | Level 2 | Level : Level 2 | 3.8 | 13678 | 0.1375 | 0.164042 | 0.328084 | 0.171875 | 0.34375 | 0.192708 | 90 | 100 mmø-100 mmø | 0.192708 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Hydronic Supply | Hydronic Supply 1
698552 | Level 1 | Level 2 | Level : Level 2 | -1.5 | 7183 | 0.0291667 | 0.0328084 | 0.0656168 | 0.0364583 | 0.0729167 | 0.0572917 | 90 | 20 mmø-20 mmø | 0.0572917 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1078311 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 14025 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1082178 | 1CC1 | Level 2 | Level : Level 2 | -1.5 | 14326 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1082560 | 2C02 | Level 2 | Level : Level 2 | 0.2 | 14365 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
693503 | 2D13 | Level 2 | Level : Level 2 | 0.3 | 6622 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
706729 | TOF Footing | Level 1 | Level : Level 1 | -0.3 | 8119 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1079970 | Level 1 | Level 1 | Level : Level 1 | 0.2 | 14144 | 0.0198079 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.0445677 | 87.1092 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
1078326 | 1D31 | Level 1 | Level : Level 1 | 0.806263 | 14031 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1079205 | Level 1 | Level 1 | Level : Level 1 | 0.3 | 14095 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Hot Water | Domestic Hot Water 1
689636 | 1C16 | Level 1 | Level : Level 1 | 0.371263 | 6198 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
694227 | 2C16 | Level 2 | Level : Level 2 | 0.806263 | 6685 | 0.0208333 | 0.0246063 | 0.0492126 | 0.0260417 | 0.0520833 | 0.046875 | 90 | 15 mmø-15 mmø | 0.046875 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Domestic Cold Water | Domestic Cold Water 1
1150895 | 2CS3 | Roof - Main | Level : Roof - Main | -0.905 | 15703 | 0.0375 | 0.131234 | 0.262467 | 0.046875 | 0.09375 | 0.0677083 | 90 | 80 mmø-80 mmø | 0.0677083 |  |  |  |  |  |  | Sanitary | Storm
692349 | Level 1 | Level 2 | Level : Level 2 | -0.411 | 6501 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Default Sanitary (cskender)
1086039 | Level 2 | Level 2 | Level : Level 2 | 0.873 | 14675 | 0.0458333 | 0.0524934 | 0.104987 | 0.0572917 | 0.114583 | 0.078125 | 90 | 32 mmø-32 mmø | 0.078125 | TagNumber | InstallationDate | SerialNumber | WarrantyStartDate | BarCode | AssetIdentifier | Sanitary | Sanitary 1
