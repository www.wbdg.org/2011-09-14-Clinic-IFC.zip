Properties of the parts of a building model (IFC2X3), part 293 of 295

# IfcFlowTerminal: 600 x 600 Face 300 x 300 Connection (283)
Name | In | Level | Host | System Type | System Name | TagNumber = Mark
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568876 | 2B11 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568823 | 2AC4 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566663 | 1E28 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568854 | 2DC2 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566566 | 1A03 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568822 | 2A02 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566607 | 1D23 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568808 | 2C17 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568888 | 2D20 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568811 | 2C06 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | D
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566676 | 1E33 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566623 | 1D40 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568837 | 2C03 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566576 | 1A14 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566574 | 1A16 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566560 | 1A08 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566624 | 1BC4 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566614 | 1DC6 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566591 | 1DC4 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568856 | 2D04-A | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568881 | 2B21 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566619 | 1D35 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568821 | 2AC3 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568879 | 2B17 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566678 | 1EC1 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568807 | 2C17 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566547 | 1C18 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566604 | 1DC1 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566558 | 1C04 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568843 | 2C22 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566567 | 1A16 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568883 | 2B16 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566611 | 1D25 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566627 | 1B13 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568829 | 2A10 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568904 | 2D07 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566669 | 1EC1 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566667 | 1E24 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566557 | 1C05 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568871 | 2BC5 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568845 | 2AC2 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566596 | 1D21 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566571 | 1A01 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568839 | 2C10 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | D
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568872 | 2B3 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568908 | 2D11 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568851 | 2A01 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566575 | 1A15 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566615 | 1DC5 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568889 | 2D21 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566681 | 1E30 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568855 | 2D04-A | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566617 | 1D31 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568859 | 2D04 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566613 | 1D25 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566593 | 1D16 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568890 | 2D21 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568852 | 2A01 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568887 | 2D20 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566618 | 1DC7 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566664 | 1E24 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566555 | 1CC2 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566565 | 1A05 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568892 | 2D17 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568893 | 2D15 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568906 | 2D09 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566620 | 1DC8 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568833 | 2CC3 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568902 | 2D18 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566577 | 1A16 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568891 | 2D19 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566600 | 1DC1 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566573 | 1A01 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568900 | 2D18 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568873 | 2B4 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566594 | 1D16 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566595 | 1D16 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568905 | 2D08 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568899 | 2D16 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568840 | 2C12 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | D
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566612 | 1D25 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568884 | 2BC3 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566677 | 1EC3 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568882 | 2B18 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568903 | 2D18 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566610 | 1D25 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568894 | 2D18 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568841 | 2C19 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566616 | 1D30 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566598 | 1D20 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566626 | 1B13 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566609 | 1D25 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568880 | 2BC3 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568849 | 2AC5 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568907 | 2D10 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568846 | 2A11 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566601 | 1D22 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568901 | 2D18 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568911 | 2CC4 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568848 | 2A11 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568853 | 2DC2 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566665 | 1E24 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568898 | 2D14 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568895 | 2D18 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568910 | 2C17 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | C
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568886 | 2B14 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568834 | 2C07 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | F
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568896 | 2D18 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566599 | 1D22 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566602 | 1DC1 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568885 | 2BC2 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568897 | 2D18 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568874 | 2B7 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568850 | 2A14 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566597 | 1D21 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:568847 | 2A14 | Level 2 | Level : Level 2 | Supply Air | Mechanical Supply Air 2 | B
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566666 | 1E22 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | A
M_Supply Diffuser:600 x 600 Face 300 x 300 Connection:600 x 600 Face 300 x 300 Connection:566625 | 1B13 | Level 1 | Level : Level 1 | Supply Air | Mechanical Supply Air 1 | B

# IfcFlowTerminal: 710 mmx710 mm, M_Sink - Mop:710 mmx710 mm:710 mmx710 mm:653536
In: 2B2
Type - ElementType: 710 mmx710 mm; PredefinedType: SINK
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; Type Mark: P4700; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories
PSet_Revit_Type_Other - Half Sink Width: 0.355 m; Half Sink Length: 0.355 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Dimensions - Sink Width: 0.71 m; Sink Length: 0.71 m; Sanitary Radius: 0.082021; Sanitary Diameter: 0.164042
PSet_Revit_Type_Mechanical - WFU: 2; HWFU: 0; CWFU: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Level: Level 2; Host: Level : Level 2; Offset: 0 m
PSet_Revit_Identity Data - Mark: 111
PSet_Revit_Mechanical - System Type: Sanitary; System Name: Sanitary 1
PSet_Revit_Other - TagNumber: P4700; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier

# IfcFlowTerminal: 800mm (18)
Type - ElementType: 800mm
PSet_Revit_Mechanical - Airflow - Pressure Drop: 1.524; Flow: 8.29895
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1
PSet_Revit_Constraints - Level: Level 1; Host: Level : Level 1
PSet_Revit_Other - TagNumber: A; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: A
PSet_Revit_Type_Mechanical - Airflow - Min Flow: 1130.07; Max Flow: 5297.2
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles
PSet_Revit_Type_Dimensions - Width: 0.8 m; Height: 0.3 m; Duct Width: 2.62467; Duct Height: 0.984252
PSet_Revit_Type_Other - Half Height: 0.15 m; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Supply Diffuser - Sidewall:800mm:800mm:...) | In | Offset (m)
570476 | Level 1 | 3.545
570475 | Level 1 | 3.545
570477 | Level 1 | 3.545
570517 | Level 1 | 3.454
570479 | 1AC1 | 3.545
570480 | 1AC1 | 3.545
570478 | Level 1 | 3.545
570519 | Level 1 | 3.454
570516 | Level 1 | 3.454
570518 | 1AC1 | 3.454
570514 | Level 1 | 3.454
570515 | 1AC1 | 3.454
570513 | 1AC1 | 3.454
570512 | 1AC1 | 3.454
570509 | Level 1 | 3.31907
570510 | Level 1 | 3.31907
570511 | Level 1 | 3.31906
570508 | Level 1 | 3.31906

# IfcFlowTerminal: 915 mmx915 mm - Public (3)
Type - ElementType: 915 mmx915 mm - Public; PredefinedType: SHOWER
PSet_Revit_Constraints - Offset: 0 m
PSet_Revit_Plumbing - Flow Pressure: 16812.2
PSet_Revit_Mechanical - System Type: Sanitary,Domestic Cold Water,Domestic Hot Water; System Name: Sanitary 1,Domestic Cold Water 1,Domestic Hot Water 1
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: P5040; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; Type Mark: P5040; OmniClass Number: 23.45.05.14.21.11; OmniClass Title: Bath/Shower Units
PSet_Revit_Type_Mechanical - WFU: 2; HWFU: 3; CWFU: 3
PSet_Revit_Type_Dimensions - Shower Width: 0.915 m; Shower Length: 0.915 m; Shower Height: 1.524 m; Sanitary Radius: 0.0410105; Sanitary Diameter: 0.082021; Hot Water Radius: 0.0246063; Hot Water Diameter: 0.0492126; Handle Height: 0.838 m; Door Width: 0.572 m; Cold Water Radius: 0.0246063; Cold Water Diameter: 0.0492126
PSet_Revit_Type_Other - Length 1: 0.0381 m; Half Door Width: 0.286 m; Angle: 45 deg; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Shower Stall - Rectangular:915 mmx915 mm - Public:915 mmx915 mm - Public:...) | In | Level | Host | Mark
620358 | 1D18 | Level 1 | Level : Level 1 | 55
652945 | 2C08 | Level 2 | Level : Level 2 | 106
652844 | 2C07 | Level 2 | Level : Level 2 | 105

# IfcFlowTerminal: GFCI (3)
Type - ElementType: GFCI; PredefinedType: POWEROUTLET
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Host: Linked Revit Model : Clinic_A.rvt; Offset: 0 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Electrical - Circuiting - Electrical Data: 120 V/1-180 VA
PSet_Revit_Type_Identity Data - Label: GFCI; Manufacturer: Manufacturer; OmniClass Number: 23.80.50.11.17; OmniClass Title: Ground Fault Receptacles
PSet_Revit_Type_Constraints - Default Elevation: 1.2 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Electrical - Switch Voltage: 1291.67; Load Classification: Receptacle; Load: 1937.5
Name (M_Duplex Receptacle:GFCI:GFCI:...) | In | Schedule Level | Elevation (m) | Mark | Panel | Circuit Number
940963 | 2B22 | Level 2 | 0.5 | 542 | N22B1 | 24
946499 | 2B6 | Level 2 | 0.5 | 590 | N22B1 | 14
868750 | 1C03 | Level 1 | 1 | 69 | N21C | 14

# IfcFlowTerminal: Public - 6.1 Lpf (24)
Type - ElementType: Public - 6.1 Lpf; PredefinedType: WCSEAT
PSet_Revit_Plumbing - Flow Pressure: 52538.1
PSet_Revit_Other - TagNumber: P9050; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Domestic Cold Water,Sanitary; System Name: Domestic Cold Water 1,Sanitary 1
PSet_Revit_Constraints - Elevation: 0.43 m
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; Type Mark: P9050; OmniClass Number: 23.45.05.21.11.11; OmniClass Title: Water Operated Water Closets
PSet_Revit_Type_Mechanical - WFU: 4; HWFU: 0; CWFU: 10
PSet_Revit_Type_Constraints - Default Elevation: 0.43 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Dimensions - Sanitary Radius: 0.164042; Sanitary Diameter: 0.328084; Cold Water Radius: 0.0410105; Cold Water Diameter: 0.082021
Name (M_Water Closet - Flush Valve - Wall Mounted:Public - 6.1 Lpf:Public - 6.1 Lpf:...) | In | Mark | Schedule Level | Host
652572 | 2C08 | 102 | Level 2 | Linked Revit Model : Clinic_A.rvt
652596 | 2C07 | 103 | Level 2 | Linked Revit Model : Clinic_A.rvt
649349 | 2D13 | 74 | Level 2 | Linked Revit Model : Clinic_A.rvt
681203 | 1B11 | 118 | Level 1 | Linked Revit Model : Clinic_A.rvt
683476 | 1D26 | 121 | Level 1 | Linked Revit Model : Clinic_A.rvt
620695 | 1A12 | 58 | Level 1 | Linked Revit Model : Clinic_A.rvt
652072 | 2C24 | 97 | Level 2 | Linked Revit Model : Clinic_A.rvt
620629 | 1A09 | 57 | Level 1 | Linked Revit Model : Clinic_A.rvt
620590 | 1A09 | 56 | Level 1 | Linked Revit Model : Clinic_A.rvt
613870 | 1C12 | 33 | Level 1 | Linked Revit Model : Clinic_A.rvt
653252 | 2B5 | 108 | Level 2 | Linked Revit Model : Clinic_A.rvt
649166 | 2B22 | 71 | Level 2 | Linked Revit Model : Clinic_A.rvt
652111 | 2C24 | 98 | Level 2 | Linked Revit Model : Clinic_A.rvt
608513 | 1E10 | 14 | Level 1 | Linked Revit Model : Clinic_A.rvt
652032 | 2C23 | 96 | Level 2 | Linked Revit Model : Clinic_A.rvt
653204 | 2B6 | 107 | Level 2 | Grid : 2
620304 | 1D18 | 54 | Level 1 | Linked Revit Model : Clinic_A.rvt
622190 | 1A13 | 64 | Level 1 | Linked Revit Model : Clinic_A.rvt
613410 | 1B05 | 30 | Level 1 | Linked Revit Model : Clinic_A.rvt
617689 | 1D04 | 47 | Level 1 | Linked Revit Model : Clinic_A.rvt
608521 | 1E09 | 15 | Level 1 | Linked Revit Model : Clinic_A.rvt
609225 | 1E12 | 18 | Level 1 | Linked Revit Model : Clinic_A.rvt
617710 | 1D14 | 48 | Level 1 | Linked Revit Model : Clinic_A.rvt
612622 | 1B02 | 27 | Level 1 | Linked Revit Model : Clinic_A.rvt

# IfcFlowTerminal: Single Pole (232)
Type - ElementType: Single Pole
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Electrical - Circuiting - Electrical Data: 120 V/1-0 VA
PSet_Revit_Electrical - Switch Voltage: 1291.67
PSet_Revit_Constraints - Elevation: 1.2 m; Offset: 0 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Electrical - Load Classification: Other
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.80.50.11.14; OmniClass Title: Switches
PSet_Revit_Type_Constraints - Default Elevation: 1.2 m
PSet_Revit_Type_Electrical - Loads - Apparent Load: 0
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Lighting Switches:Single Pole:Single Pole:...) | In | Panel | Circuit Number | Host | Schedule Level
821134 | 1B19 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
820075 | 1BC3 | L41B | 2 | Linked Revit Model : Clinic_A.rvt | Level 1
801519 | 1D08 | L41C | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
795878 | 1C19 | L41C | 4 | Linked Revit Model : Clinic_A.rvt | Level 1
846589 | 2D20 | L42B | 7 | Linked Revit Model : Clinic_A.rvt | Level 2
820512 | 1BC4 | L41B | 2 | Linked Revit Model : Clinic_A.rvt | Level 1
821262 | 1B19 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
846331 | 2D20 | L42B | 7 | Linked Revit Model : Clinic_A.rvt | Level 2
848806 | 2D10 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | Level 2
841350 | 2B7 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
841615 | 2B9 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
818986 | 1E22 | L41B | 6 | Grid : 6.7 | Level 1
804030 | 1C07 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt | Level 1
801247 | 1D12 | L41C | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
846291 | 2BC2 | L42B | 4 | Linked Revit Model : Clinic_A.rvt | Level 2
801352 | 1D10 | L41C | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
820830 | 1B23 | L41B | 8 | Linked Revit Model : Clinic_A.rvt | Level 1
819880 | 1E17 | L41B | 6 | Linked Revit Model : Clinic_A.rvt | Level 1
830041 | 2C07 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | Level 2
801082 | 1D14 | L41C | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
836019 | 2DC2 | L42B | 4 | Grid : D.9 | Level 2
812766 | 1D26 | L41B | 5 | Linked Revit Model : Clinic_A.rvt | Level 1
848624 | 2D11 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | Level 2
846902 | 2D14 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | Level 2
814459 | 1E04 | L41B | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
846829 | 2D17 | L42B | 6 | Orphaned | Level 2
833917 | 2A11 | L42C | 7 | Linked Revit Model : Clinic_A.rvt | Level 2
799512 | 1D16 | L41C | 5 | Linked Revit Model : Clinic_A.rvt | Level 1
830178 | 2C05 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | Level 2
847690 | 2D12 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | Level 2
814012 | 1E10 | L41B | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
846652 | 2D19 | L42B | 6 | Orphaned | Level 2
808334 | 1A13 | N21C1 | 24 | Linked Revit Model : Clinic_A.rvt | Level 1
850424 | 2D18 | L42B | 5 | Linked Revit Model : Clinic_A.rvt | Level 2
836895 | 2CC1 | L42C | 3 | Linked Revit Model : Clinic_A.rvt | Level 2
813945 | 1E09 | L41B | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
800541 | 1D19 | L41C | 5 | Linked Revit Model : Clinic_A.rvt | Level 1
843801 | 2B23 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
829252 | 2C12 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
804075 | 1C07 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt | Level 1
847584 | 2D13 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | Level 2
817900 | 1E24 | L41B | 7 | Linked Revit Model : Clinic_A.rvt | Level 1
827675 | 2C16 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
798847 | 1C17 | L41C | 4 | Linked Revit Model : Clinic_A.rvt | Level 1
813556 | 1E11 | L41B | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
819572 | 1E16 | L41B | 6 | Linked Revit Model : Clinic_A.rvt | Level 1
835627 | 2C08 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | Level 2
796348 | 1C14 | L41C | 4 | Linked Revit Model : Clinic_A.rvt | Level 1
818809 | 1E21 | L41B | 6 | Linked Revit Model : Clinic_A.rvt | Level 1
805044 | 1C04 | L41C | 9 | Linked Revit Model : Clinic_A.rvt | Level 1
832876 | 2A02 | L42C | 6 | Linked Revit Model : Clinic_A.rvt | Level 2
844548 | 2B10 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | Level 2
821628 | 1B19 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
841939 | 2B3 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
817744 | 1E28 | L41B | 7 | Linked Revit Model : Clinic_A.rvt | Level 1
833594 | 2A01 | L42C | 6 | Linked Revit Model : Clinic_A.rvt | Level 2
843352 | 2B5 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | Level 2
818059 | 1E24 | L41B | 7 | Linked Revit Model : Clinic_A.rvt | Level 1
817233 | 1D39 | L41B | 4 | Linked Revit Model : Clinic_A.rvt | Level 1
840056 | 2D04-A | L42B | 2 | Linked Revit Model : Clinic_A.rvt | Level 2
819445 | 1E19 | L41B | 6 | Linked Revit Model : Clinic_A.rvt | Level 1
843519 | 2B25 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | Level 2
829157 | 2C11 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
850240 | 2A01 | L42C | 6 | Linked Revit Model : Clinic_A.rvt | Level 2
835701 | 2C07 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | Level 2
841678 | 2B4 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
819190 | 1E30 | L41B | 6 | Linked Revit Model : Clinic_A.rvt | Level 1
800786 | 1D15 | L41C | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
821969 | 1B09 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
840967 | 2BC6 | L42B | 4 | Linked Revit Model : Clinic_A.rvt | Level 2
841093 | 2BC6 | L42B | 4 | Linked Revit Model : Clinic_A.rvt | Level 2
805694 | 1A10 | N21C1 | 23 | Orphaned | Level 1
839952 | 2D18 | L42B | 5 | Linked Revit Model : Clinic_A.rvt | Level 2
803313 | 1D13 | L41C | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
844160 | 2B14 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | Level 2
845761 | 2B16 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
796984 | 1C12 | L41C | 4 | Linked Revit Model : Clinic_A.rvt | Level 1
830345 | 2C04 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | Level 2
798440 | 1C15 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt | Level 1
829849 | 2C08 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | Level 2
844253 | 2B13 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | Level 2
843118 | 2B01 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
843150 | 2BC5 | L42B | 4 | Linked Revit Model : Clinic_A.rvt | Level 2
804666 | 1C09 | L41C | 9 | Linked Revit Model : Clinic_A.rvt | Level 1
812883 | 1D25 | L41B | 5 | Linked Revit Model : Clinic_A.rvt | Level 1
843939 | 2B17 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | Level 2
845612 | 2B18 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
835745 | 2C19 | L42C | 2 | Grid : 6 | Level 2
837305 | 2D05 | L42C | 9 | Grid : 6 | Level 2
799439 | 1C13 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt | Level 1
844781 | 2B6 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | Level 2
814134 | 1E07 | L41B | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
807245 | 1A04 | L41C | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
807125 | 1A06 | L41C | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
808853 | 1DC4 | L41C | 6 | Linked Revit Model : Clinic_A.rvt | Level 1
832546 | 2A04 | L42C | 6 | Linked Revit Model : Clinic_A.rvt | Level 2
814607 | 1E01 | L41B | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
844003 | 2B15 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | Level 2
818499 | 1E20 | L41B | 6 | Linked Revit Model : Clinic_A.rvt | Level 1
805499 | 1A12 | N21C1 | 23 | Linked Revit Model : Clinic_A.rvt | Level 1
826019 | 1C02 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt | Level 1
838010 | 2D09 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | Level 2
803418 | 1C02 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt | Level 1
813009 | 1E14 | L41B | 5 | Linked Revit Model : Clinic_A.rvt | Level 1
827828 | 2C13 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
833311 | 2A14 | L42C | 7 | Linked Revit Model : Clinic_A.rvt | Level 2
813301 | 1E33 | L41B | 3 | Grid : 7 | Level 1
806189 | 1A07 | L41C | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
819825 | 1E18 | L41B | 6 | Linked Revit Model : Clinic_A.rvt | Level 1
815581 | 1D40 | L41B | 4 | Linked Revit Model : Clinic_A.rvt | Level 1
807422 | 1AC5 | L41C | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
813186 | 1E12 | L41B | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
829579 | 2C10 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
804939 | 1C05 | L41C | 9 | Linked Revit Model : Clinic_A.rvt | Level 1
814350 | 1E06 | L41B | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
850233 | 2A01 | L42C | 6 | Linked Revit Model : Clinic_A.rvt | Level 2
828216 | 2C17 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
838833 | 2D07 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | Level 2
799568 | 1D17 | L41C | 5 | Linked Revit Model : Clinic_A.rvt | Level 1
841296 | 2BC5 | L42B | 4 | Linked Revit Model : Clinic_A.rvt | Level 2
800467 | 1D20 | L41C | 5 | Linked Revit Model : Clinic_A.rvt | Level 1
830604 | 2C03 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | Level 2
819214 | 1EC4 | L41B | 2 | Linked Revit Model : Clinic_A.rvt | Level 1
837031 | 2C18 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
834510 | 2AC2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt | Level 2
801956 | 1D02 | L41C | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
843258 | 2BC4 | L42B | 4 | Linked Revit Model : Clinic_A.rvt | Level 2
806381 | 1AC5 | L41C | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
830500 | 2C02 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | Level 2
804129 | 1C08 | L41C | 9 | Linked Revit Model : Clinic_A.rvt | Level 1
840473 | 2D02 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | Level 2
828798 | 2C15 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
817560 | 1E26 | L41B | 7 | Linked Revit Model : Clinic_A.rvt | Level 1
815223 | 1B21 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
827714 | 2C14 | L42C | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
819278 | 1E23 | L41B | 6 | Grid : B | Level 1
834867 | 2C22 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | Level 2
844674 | 2B8 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | Level 2
838503 | 2D08 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | Level 2
845878 | 2BC3 | L42B | 4 | Linked Revit Model : Clinic_A.rvt | Level 2
806465 | 1A05 | L41C | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
807734 | 1A15 | N21C1 | 24 | Linked Revit Model : Clinic_A.rvt | Level 1
830657 | 2C01 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | Level 2
800165 | 1D21 | L41C | 5 | Linked Revit Model : Clinic_A.rvt | Level 1
847049 | 2D15 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | Level 2
805558 | 1AC4 | N21C1 | 24 | Linked Revit Model : Clinic_A.rvt | Level 1
795927 | 1C16 | L41C | 4 | Linked Revit Model : Clinic_A.rvt | Level 1
843727 | 2B24 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
815105 | 1D38 | L41B | 4 | Linked Revit Model : Clinic_A.rvt | Level 1
805799 | 1A11 | N21C1 | 24 | Linked Revit Model : Clinic_A.rvt | Level 1
797783 | 1C11 | L41C | 2 | Linked Revit Model : Clinic_A.rvt | Level 1
813365 | 1E15 | L41B | 5 | Linked Revit Model : Clinic_A.rvt | Level 1
804855 | 1C06 | L41C | 9 | Linked Revit Model : Clinic_A.rvt | Level 1
803163 | 1D11 | L41C | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
834824 | 2C23 | L42C | 2 | Grid : E.3 | Level 2
806115 | 1A16 | N21C1 | 24 | Linked Revit Model : Clinic_A.rvt | Level 1
805904 | 1A08 | N21C1 | 23 | Linked Revit Model : Clinic_A.rvt | Level 1
828923 | 2CC5 | L42C | 3 | Linked Revit Model : Clinic_A.rvt | Level 2
817531 | 1DC1 | L41C | 8 | Linked Revit Model : Clinic_A.rvt | Level 1
829725 | 2C06 | L42C | 5 | Linked Revit Model : Clinic_A.rvt | Level 2
840265 | 2D04 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | Level 2
803110 | 1D09 | L41C | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
831788 | 2A12 | L42C | 7 | Grid : F | Level 2
816136 | 1D35 | L41B | 4 | Orphaned | Level 1
814717 | 1E02 | L41B | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
844413 | 2B12 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | Level 2
842128 | 2B2 | L42B | 1 | <not associated> | Level 2
816486 | 1D36 | L41B | 4 | Linked Revit Model : Clinic_A.rvt | Level 1
817668 | 1E27 | L41B | 7 | Linked Revit Model : Clinic_A.rvt | Level 1
816508 | 1D34 | L41B | 4 | Linked Revit Model : Clinic_A.rvt | Level 1
839210 | 2D06 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | Level 2
823066 | 1B06 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
828563 | 2CC5 | L42C | 3 | Linked Revit Model : Clinic_A.rvt | Level 2
845507 | 2B20 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
840574 | 2BC1 | L42B | 4 | Linked Revit Model : Clinic_A.rvt | Level 2
805429 | 1A09 | N21C1 | 23 | Linked Revit Model : Clinic_A.rvt | Level 1
806667 | 1A03 | L41C | 1 | Orphaned | Level 1
843886 | 2B19 | L42B | 3 | Linked Revit Model : Clinic_A.rvt | Level 2
834262 | 2AC1 | L42C | 3 | Grid : E.3 | Level 2
830993 | 2A10 | L42C | 7 | Linked Revit Model : Clinic_A.rvt | Level 2
834624 | 2C24 | L42C | 2 | Linked Revit Model : Clinic_A.rvt | Level 2
812618 | 1DC6 | L41B | 4 | Linked Revit Model : Clinic_A.rvt | Level 1
803770 | 1C10 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt | Level 1
831395 | 2A05 | L42C | 8 | Linked Revit Model : Clinic_A.rvt | Level 2
812075 | 1D24 | L41B | 5 | Linked Revit Model : Clinic_A.rvt | Level 1
831048 | 2A11 | L42C | 7 | Grid : F | Level 2
805222 | 1CC1 | L41C | 2 | Linked Revit Model : Clinic_A.rvt | Level 1
831649 | 2A03 | L42C | 6 | Linked Revit Model : Clinic_A.rvt | Level 2
830720 | 2A09 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | Level 2
831153 | 2A08 | L42C | 4 | Linked Revit Model : Clinic_A.rvt | Level 2
816770 | 1D28 | L41B | 4 | Linked Revit Model : Clinic_A.rvt | Level 1
847471 | 2D16 | L42B | 6 | Linked Revit Model : Clinic_A.rvt | Level 2
814259 | 1E07 | L41B | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
829485 | 2C09 | L42C | 5 | Linked Revit Model : Clinic_A.rvt | Level 2
802702 | 1D05 | N21C1 | 24 | Linked Revit Model : Clinic_A.rvt | Level 1
809790 | 1D18 | L41C | 5 | Linked Revit Model : Clinic_A.rvt | Level 1
830949 | 2AC2 | L42C | 3 | Linked Revit Model : Clinic_A.rvt | Level 2
801562 | 1D01 | L41C | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
814814 | 1E03 | L41B | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
839646 | 2D06 | L42B | 6 | Grid : 6 | Level 2
810640 | 1D22 | L41C | 5 | Linked Revit Model : Clinic_A.rvt | Level 1
810587 | 1D22 | L41C | 5 | Linked Revit Model : Clinic_A.rvt | Level 1
824335 | 1B01 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
802435 | 1D04 | L41C | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
816706 | 1D32 | L41B | 4 | Linked Revit Model : Clinic_A.rvt | Level 1
844874 | 2B22 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
808165 | 1A14 | N21C1 | 24 | Linked Revit Model : Clinic_A.rvt | Level 1
802982 | 1D07 | L41C | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
829306 | 2CC4 | L42C | 3 | Linked Revit Model : Clinic_A.rvt | Level 2
811985 | 1D23 | L41B | 5 | Linked Revit Model : Clinic_A.rvt | Level 1
823724 | 1B02 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
816853 | 1D31 | L41B | 4 | Linked Revit Model : Clinic_A.rvt | Level 1
840501 | 2D01 | L42B | 2 | Linked Revit Model : Clinic_A.rvt | Level 2
822180 | 1B17 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
831311 | 2A06 | L42C | 8 | Linked Revit Model : Clinic_A.rvt | Level 2
802817 | 1D06 | N21C1 | 24 | Linked Revit Model : Clinic_A.rvt | Level 1
823139 | 1B04 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
812252 | 1D27 | L41B | 5 | Linked Revit Model : Clinic_A.rvt | Level 1
831258 | 2A07 | L42C | 8 | Linked Revit Model : Clinic_A.rvt | Level 2
831529 | 2A13 | L42C | 7 | Linked Revit Model : Clinic_A.rvt | Level 2
803717 | 1C03 | N21C1 | 22 | Linked Revit Model : Clinic_A.rvt | Level 1
824211 | 1BC1 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
823003 | 1B08 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
822735 | 1B10 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
812430 | 1D30 | L41B | 4 | Linked Revit Model : Clinic_A.rvt | Level 1
814969 | 1E05 | L41B | 3 | Linked Revit Model : Clinic_A.rvt | Level 1
817170 | 1D33 | L41B | 4 | Linked Revit Model : Clinic_A.rvt | Level 1
822076 | 1B05 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
845255 | 2B21 | L42B | 1 | Linked Revit Model : Clinic_A.rvt | Level 2
822413 | 1B04 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
821991 | 1B07 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | Level 1
822650 | 1B11 | L41B | 1 | Linked Revit Model : Clinic_A.rvt | Level 1

# IfcFlowTerminal: Standard (6)
In: Level 1
Type - ElementType: Standard
PSet_Revit_Mechanical - Airflow - Pressure Drop: 1.524; Flow: 8.29895
PSet_Revit_Identity Data - Mark: A
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Level: Level 1; Host: Level : Level 1; Offset: 3.454 m
PSet_Revit_Other - TagNumber: A; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles
PSet_Revit_Type_Dimensions - Width: 1.2 m; Height: 0.3 m; Duct Width: 3.93701; Duct Height: 0.984252
PSet_Revit_Type_Mechanical - Airflow - Min Flow: 1130.07; Max Flow: 5297.2
PSet_Revit_Type_Other - Half Height: 0.15 m; ModelNumber: ModelNumber; ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
Name (M_Supply Diffuser - Sidewall:Standard:Standard:...)
570489
570490
570487
570495
570496
570488

# IfcFlowTerminal: Standard (958)
Type - ElementType: Standard; PredefinedType: POWEROUTLET
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Electrical - Circuiting - Electrical Data: 120 V/1-180 VA
PSet_Revit_Constraints - Offset: 0 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Constraints - Default Elevation: 0.46 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; ModelLabel: ModelLabel
PSet_Revit_Type_Electrical - Switch Voltage: 1291.67; Load Classification: Receptacle; Load: 1937.5
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer; OmniClass Number: 23.80.50.11.17; OmniClass Title: Ground Fault Receptacles
Name (M_Duplex Receptacle:Standard:Standard:...) | In | Mark | Panel | Circuit Number | Host | Elevation (m) | Schedule Level
941631 | 2B01 | 551 | N22B1 | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
940819 | 2B21 | 540 | N22B1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
942677 | 2B4 | 561 | N22B1 | 5 | M_Lighting Switches : Single Pole | 0.5 | Level 2
943593 | 2B7 | 565 | N22B1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
942806 | 2B4 | 563 | N22B1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
865521 | 1C11 | 33 | N21C | 22 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
942192 | 2B3 | 557 | N22B1 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
941433 | 2B24 | 549 | N22B1 | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
861782 | 1C19 | 2 | N21C | 3 | M_Lighting Switches : Single Pole | 0.5 | Level 1
940593 | 2B21 | 539 | N22B1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
947367 | 2B10 | 599 | N22B1 | 27 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
943343 | 2B7 | 564 | N22B1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
878678 | 1A01 | 173 | N21B1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
878085 | 1A03 | 165 | N21B1 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
861952 | 1C19 | 4 | N21C | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
953381 | 2D01 | 651 | N22B | 26 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
940477 | 2B21 | 537 | N22B1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
945103 | 2B2 | 577 | N22B1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
944059 | 2B11 | 571 | N22B1 | 26 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
940898 | 2B22 | 541 | N22B1 | 24 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
943637 | 2B7 | 566 | N22B1 | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
953583 | 2DC1 | 652 | N22B | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
946922 | 2B10 | 595 | N22B1 | 27 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
941789 | 2B01 | 552 | N22B1 | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
941993 | 2B3 | 555 | N22B1 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
874442 | 1C07 | 130 | N21C | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
946759 | 2B8 | 594 | N22B1 | 22 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
862523 | 1C16 | 8 | N21C | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
865693 | Level 1 | 34 | N21C | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
948136 | 2B17 | 608 | N22B1 | 16 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
944924 | 2AC1 | 576 | N22B | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
878256 | 1A16 | 168 | N21B1 | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
877469 | 1A16 | 157 | N21B1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
943954 | 2B9 | 570 | N22B1 | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
951930 | 2D20 | 636 | N22B1 | 1 | Linked Revit Model : Clinic_S.rvt | 0.5 | Level 2
862619 | 1C16 | 10 | N21C | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
896439 | 1E26 | 296 | N21E2 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
941139 | 2B23 | 546 | N22B1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
917203 | 1D20 | 468 | N21C1 | 19 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
866341 | 1C09 | 37 | N21C | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
886710 | 1B04 | 220 | N21B | 2 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
878792 | 1A01 | 174 | N21B1 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
896282 | 1E26 | 293 | N21E2 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
947259 | 2B10 | 597 | N22B1 | 27 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
877816 | 1A03 | 161 | N21B1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
967991 | 2A06 | 774 | N22C | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
896097 | 1E28 | 289 | N21E2 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
940391 | 2B21 | 536 | N22B1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
896335 | 1E26 | 294 | N21E2 | 11 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
947883 | 2B15 | 605 | N22B1 | 21 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
944633 | 2B11 | 574 | N22B1 | 26 | M_Duplex Receptacle : Standard | 0.5 | Level 2
942128 | 2B3 | 556 | N22B1 | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
953627 | 2D01 | 653 | N22B | 26 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
967948 | 2A06 | 773 | N22C | 7 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
864821 | 1C15 | 26 | N21C | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
895130 | 1BC3 | 285 | N21B | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
945916 | 2B8 | 584 | N22B1 | 22 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
866007 | 1C09 | 35 | N21C | 17 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
941115 | 2B23 | 545 | N22B1 | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
945432 | 2BC5 | 578 | N22B1 | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
941909 | 2B01 | 554 | N22B1 | 8 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
943911 | 2B9 | 569 | N22B1 | 25 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
862576 | 1C16 | 9 | N21C | 4 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
920903 | 1D25 | 488 | N21E1 | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
942752 | 2B4 | 562 | N22B1 | 5 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
897406 | 1E25 | 309 | N21E2 | 10 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
861908 | 1C19 | 3 | N21C | 3 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
917246 | 1D21 | 469 | N21C1 | 20 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
877426 | 1A16 | 156 | N21B1 | 12 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
886424 | 1B04 | 217 | N21B | 6 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
952578 | 2D20 | 638 | N22B1 | 1 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
877860 | 1A03 | 162 | N21B1 | 13 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
868347 | 1C10 | 63 | N21C | 14 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 1
968545 | 2A05 | 780 | N22C | 9 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
944589 | 2B11 | 573 | N22B1 | 26 | Linked Revit Model : Clinic_A.rvt | 0.5 | Level 2
