Properties of the parts of a building model (IFC2X3), part 58 of 295

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:569071
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:569073
In: Level 2
Type - ElementType: Oval Duct:Gored Elbows / Tees:569073
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Equivalent Diameter: 1.66814; Size Lock: no; Loss Coefficient: 0.0346561; Hydraulic Diameter: 1.6292; Section: 50; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.85543 m2
PSet_Revit_Dimensions - Size: 600/400; Width: 1.9685; Height: 1.31234; Length: 1.12 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Identity Data - Mark: 1207
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 105.061; Additional Flow: 0; Velocity: 47.4585; Friction: 0.361694; Pressure Drop: 1.32906; Velocity Pressure: 38.3499; Reynolds number: 478629
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:569175
In: Level 2
Type - ElementType: Oval Duct:Gored Elbows / Tees:569175
PSet_Revit_Identity Data - Mark: 1256
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.4 m; Start Offset: 3.4 m; End Offset: 3.4 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.2 m; Top Elevation: 3.6 m; Equivalent Diameter: 1.66814; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 1.6292; Section: 518; Insulation Thickness: 0; Lining Thickness: 0; Area: 2.36669 m2
PSet_Revit_Dimensions - Size: 600/400; Width: 1.9685; Height: 1.31234; Length: 1.42861 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:569519
In: Level 2
Type - ElementType: Oval Duct:Gored Elbows / Tees:569519
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Equivalent Diameter: 1.66814; Size Lock: no; Loss Coefficient: 0.0045887; Hydraulic Diameter: 1.6292; Section: 188; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.248496 m2
PSet_Revit_Mechanical - Airflow - Flow: 120.07; Additional Flow: 0; Velocity: 54.2383; Friction: 0.467048; Pressure Drop: 0.229847; Velocity Pressure: 50.0897; Reynolds number: 547004
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Dimensions - Size: 600/400; Width: 1.9685; Height: 1.31234; Length: 0.15 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 1492
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:569521
In: Level 2
Type - ElementType: Oval Duct:Gored Elbows / Tees:569521
PSet_Revit_Identity Data - Mark: 1493
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Equivalent Diameter: 1.66814; Size Lock: no; Loss Coefficient: 0.14072; Hydraulic Diameter: 1.6292; Section: 188; Insulation Thickness: 0; Lining Thickness: 0; Area: 7.62053 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 600/400; Width: 1.9685; Height: 1.31234; Length: 4.6 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 120.07; Additional Flow: 0; Velocity: 54.2383; Friction: 0.467048; Pressure Drop: 7.04863; Velocity Pressure: 50.0897; Reynolds number: 547004
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:569523
In: Level 2
Type - ElementType: Oval Duct:Gored Elbows / Tees:569523
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Equivalent Diameter: 1.66814; Size Lock: no; Loss Coefficient: 0.248828; Hydraulic Diameter: 1.6292; Section: 209; Insulation Thickness: 0; Lining Thickness: 0; Area: 13.3219 m2
PSet_Revit_Dimensions - Size: 600/400; Width: 1.9685; Height: 1.31234; Length: 8.04151 m
PSet_Revit_Identity Data - Mark: 1494
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 105.061; Additional Flow: 0; Velocity: 47.4585; Friction: 0.361694; Pressure Drop: 9.54255; Velocity Pressure: 38.3499; Reynolds number: 478629
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:995740
In: Level 1
Type - ElementType: Oval Duct:Gored Elbows / Tees:995740
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.1 m; Top Elevation: 3.4 m; Equivalent Diameter: 1.32429; Size Lock: no; Loss Coefficient: 0.0733449; Hydraulic Diameter: 1.27752; Section: 15; Insulation Thickness: 0; Lining Thickness: 0; Area: 2.45955 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.25 m; Start Offset: 3.25 m; End Offset: 3.25 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 105.061; Additional Flow: 0; Velocity: 74.6867; Friction: 1.15893; Pressure Drop: 6.96615; Velocity Pressure: 94.978; Reynolds number: 590635
PSet_Revit_Dimensions - Size: 500/300; Width: 1.64042; Height: 0.984252; Length: 1.8321 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 363
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Gored Elbows / Tees:995741
In: Level 1
Type - ElementType: Oval Duct:Gored Elbows / Tees:995741
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.31069 m; Start Offset: 3.31069 m; End Offset: 3.63931 m; Slope: 0.57735
PSet_Revit_Dimensions - Size: 500/300; Width: 1.64042; Height: 0.984252; Length: 0.657246 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.18078 m; Top Elevation: 3.76922 m; Equivalent Diameter: 1.32429; Size Lock: no; Loss Coefficient: 0.0263117; Hydraulic Diameter: 1.27752; Section: 15; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.882338 m2
PSet_Revit_Mechanical - Airflow - Flow: 105.061; Additional Flow: 0; Velocity: 74.6867; Friction: 1.15893; Pressure Drop: 2.49903; Velocity Pressure: 94.978; Reynolds number: 590635
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 366
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Gored: Oval Elbow - Gored; Preferred Junction Type: 1; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:1114441
In: Level 2
Type - ElementType: Oval Duct:Mitered Elbows / Taps:1114441
PSet_Revit_Identity Data - Mark: 532
PSet_Revit_Dimensions - Size: 1500/500; Width: 4.92126; Height: 1.64042; Length: 0.12366 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 2.95 m; Top Elevation: 3.45 m; Equivalent Diameter: 2.95048; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 2.55922; Section: 788; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.441566 m2
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.2 m; Start Offset: 3.2 m; End Offset: 3.2 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:1114442
In: Level 2
Type - ElementType: Oval Duct:Mitered Elbows / Taps:1114442
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 2.95801 m; Top Elevation: 3.54199 m; Equivalent Diameter: 2.95048; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 2.55922; Section: 788; Insulation Thickness: 0; Lining Thickness: 0; Area: 2.33228 m2
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.2057 m; Start Offset: 3.2057 m; End Offset: 3.2943 m; Slope: 0.13691
PSet_Revit_Identity Data - Mark: 533
PSet_Revit_Dimensions - Size: 1500/500; Width: 4.92126; Height: 1.64042; Length: 0.653154 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:1115395
In: Level 2
Type - ElementType: Oval Duct:Mitered Elbows / Taps:1115395
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.4 m; Start Offset: 3.4 m; End Offset: 3.4 m; Slope: 0
PSet_Revit_Dimensions - Size: 600/400; Width: 1.9685; Height: 1.31234; Length: 0.101151 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.2 m; Top Elevation: 3.6 m; Equivalent Diameter: 1.66814; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 1.6292; Section: 517; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.167571 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 534
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:1115411
In: Level 2
Type - ElementType: Oval Duct:Mitered Elbows / Taps:1115411
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.4 m; Top Elevation: 3.8 m; Equivalent Diameter: 1.66814; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 1.6292; Section: 517; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.0925567 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Identity Data - Mark: 540
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.6 m; Start Offset: 3.6 m; End Offset: 3.6 m; Slope: 0
PSet_Revit_Dimensions - Size: 600/400; Width: 1.9685; Height: 1.31234; Length: 0.0558702 m
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:1115412
In: Level 2
Type - ElementType: Oval Duct:Mitered Elbows / Taps:1115412
PSet_Revit_Identity Data - Mark: 541
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.21256 m; Top Elevation: 3.78744 m; Equivalent Diameter: 1.66814; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 1.6292; Section: 517; Insulation Thickness: 0; Lining Thickness: 0; Area: 1.55023 m2
PSet_Revit_Dimensions - Size: 600/400; Width: 1.9685; Height: 1.31234; Length: 0.93577 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.59128 m; Start Offset: 3.59128 m; End Offset: 3.40872 m; Slope: 0.198912
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:1115512
In: Level 2
Type - ElementType: Oval Duct:Mitered Elbows / Taps:1115512
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Identity Data - Mark: 542
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 2; Offset: 3.4 m; Start Offset: 3.4 m; End Offset: 3.4 m; Slope: 0
PSet_Revit_Dimensions - Size: 600/400; Width: 1.9685; Height: 1.31234; Length: 1.98876 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 2; Bottom Elevation: 3.2 m; Top Elevation: 3.6 m; Equivalent Diameter: 1.66814; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 1.6292; Section: 517; Insulation Thickness: 0; Lining Thickness: 0; Area: 3.29466 m2
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:567276
In: Level 1
Type - ElementType: Oval Duct:Mitered Elbows / Taps:567276
PSet_Revit_Dimensions - Size: 1500/500; Width: 4.92126; Height: 1.64042; Length: 2.58415 m
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.44 m; Top Elevation: 3.94 m; Equivalent Diameter: 2.95048; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 2.55922; Section: 768; Insulation Thickness: 0; Lining Thickness: 0; Area: 9.22749 m2
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.69 m; Start Offset: 3.69 m; End Offset: 3.69 m; Slope: 0
PSet_Revit_Identity Data - Mark: 273
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:567277
In: Level 1
Type - ElementType: Oval Duct:Mitered Elbows / Taps:567277
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.69 m; Start Offset: 3.69 m; End Offset: 3.69 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 315.183; Additional Flow: 0; Velocity: 62.1227; Friction: 0.397205; Pressure Drop: 4.3647; Velocity Pressure: 65.7108; Reynolds number: 890649
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 1050/500; Width: 3.44488; Height: 1.64042; Length: 3.34931 m
PSet_Revit_Identity Data - Mark: 274
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.44 m; Top Elevation: 3.94 m; Equivalent Diameter: 2.48597; Size Lock: no; Loss Coefficient: 0.066423; Hydraulic Diameter: 2.31605; Section: 294; Insulation Thickness: 0; Lining Thickness: 0; Area: 8.94532 m2
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:567278
In: Level 1
Type - ElementType: Oval Duct:Mitered Elbows / Taps:567278
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.69 m; Start Offset: 3.69 m; End Offset: 3.69 m; Slope: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.44 m; Top Elevation: 3.94 m; Equivalent Diameter: 2.48597; Size Lock: no; Loss Coefficient: 0.109056; Hydraulic Diameter: 2.31605; Section: 293; Insulation Thickness: 0; Lining Thickness: 0; Area: 14.5115 m2
PSet_Revit_Mechanical - Airflow - Flow: 270.157; Additional Flow: 0; Velocity: 53.248; Friction: 0.295351; Pressure Drop: 5.26494; Velocity Pressure: 48.2773; Reynolds number: 763414
PSet_Revit_Dimensions - Size: 1050/500; Width: 3.44488; Height: 1.64042; Length: 5.43338 m
PSet_Revit_Identity Data - Mark: 275
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:567284
In: Level 1
Type - ElementType: Oval Duct:Mitered Elbows / Taps:567284
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.44 m; Top Elevation: 3.94003 m; Equivalent Diameter: 2.15953; Size Lock: no; Loss Coefficient: 0.412596; Hydraulic Diameter: 2.09383; Section: 304; Insulation Thickness: 0; Lining Thickness: 0; Area: 38.9042 m2
PSet_Revit_Identity Data - Mark: 278
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Dimensions - Size: 800/500; Width: 2.62467; Height: 1.64042; Length: 17.9216 m
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.69003 m; Start Offset: 3.69003 m; End Offset: 3.69 m; Slope: 0
PSet_Revit_Mechanical - Airflow - Flow: 165.096; Additional Flow: 0; Velocity: 44.2845; Friction: 0.234316; Pressure Drop: 13.7773; Velocity Pressure: 33.3918; Reynolds number: 573987
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:567285
In: Level 1
Type - ElementType: Oval Duct:Mitered Elbows / Taps:567285
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.44003 m; Top Elevation: 3.94003 m; Equivalent Diameter: 2.15953; Size Lock: no; Loss Coefficient: 0.0742804; Hydraulic Diameter: 2.09383; Section: 303; Insulation Thickness: 0; Lining Thickness: 0; Area: 6.86917 m2
PSet_Revit_Identity Data - Mark: 279
PSet_Revit_Dimensions - Size: 800/500; Width: 2.62467; Height: 1.64042; Length: 3.16435 m
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Mechanical - Airflow - Flow: 135.079; Additional Flow: 0; Velocity: 36.2328; Friction: 0.159935; Pressure Drop: 1.66041; Velocity Pressure: 22.3532; Reynolds number: 469625
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.69003 m; Start Offset: 3.69003 m; End Offset: 3.69003 m; Slope: 0
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:567306
In: Level 1
Type - ElementType: Oval Duct:Mitered Elbows / Taps:567306
PSet_Revit_Identity Data - Mark: 289
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.50953 m; Start Offset: 3.50953 m; End Offset: 3.5 m; Slope: 0.00731491
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.375 m; Top Elevation: 3.63452 m; Equivalent Diameter: 0.75243; Size Lock: no; Loss Coefficient: 0.107183; Hydraulic Diameter: 0.746262; Section: 425; Insulation Thickness: 0; Lining Thickness: 0; Area: 0.948394 m2
PSet_Revit_Dimensions - Size: 200/250; Width: 0.656168; Height: 0.82021; Length: 1.30217 m
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Mechanical - Airflow - Flow: 15.0087; Additional Flow: 0; Velocity: 33.6672; Friction: 0.484195; Pressure Drop: 2.06858; Velocity Pressure: 19.2996; Reynolds number: 155527
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:567691
In: Level 1
Type - ElementType: Oval Duct:Mitered Elbows / Taps:567691
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.44 m; Top Elevation: 3.94 m; Equivalent Diameter: 2.00694; Size Lock: no; Loss Coefficient: 0.0288152; Hydraulic Diameter: 1.97337; Section: 271; Insulation Thickness: 0; Lining Thickness: 0; Area: 2.3287 m2
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.69 m; Start Offset: 3.69 m; End Offset: 3.69 m; Slope: 0
PSet_Revit_Dimensions - Size: 700/500; Width: 2.29659; Height: 1.64042; Length: 1.1816 m
PSet_Revit_Mechanical - Airflow - Flow: 165.096; Additional Flow: 0; Velocity: 51.7562; Friction: 0.33902; Pressure Drop: 1.31426; Velocity Pressure: 45.6101; Reynolds number: 632236
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Identity Data - Mark: 556
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:567693
In: Level 1
Type - ElementType: Oval Duct:Mitered Elbows / Taps:567693
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.44 m; Top Elevation: 3.94 m; Equivalent Diameter: 1.83651; Size Lock: no; Loss Coefficient: 0.0777599; Hydraulic Diameter: 1.82569; Section: 269; Insulation Thickness: 0; Lining Thickness: 0; Area: 5.13531 m2
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.69 m; Start Offset: 3.69 m; End Offset: 3.69 m; Slope: 0
PSet_Revit_Dimensions - Size: 600/500; Width: 1.9685; Height: 1.64042; Length: 2.9 m
PSet_Revit_Mechanical - Airflow - Flow: 135.079; Additional Flow: 0; Velocity: 50.9407; Friction: 0.361109; Pressure Drop: 3.43575; Velocity Pressure: 44.1841; Reynolds number: 575708
PSet_Revit_Identity Data - Mark: 557
PSet_Revit_Type_Other - ExpectedLife: ExpectedLife; ReplacementCost: ReplacementCost; AssetAccountingType: FIXED; AccessibilityPerformance: AccessibilityPerformance; CodePerformance: CodePerformance; Color: Color; Constituents: Constituents; Features: Features; Finish: Finish; Grade: Grade; Material: Material; ModelReference: ModelReference; NominalHeight: NominalHeight; NominalLength: NominalLength; NominalWidth: NominalWidth; ProductionYear: ProductionYear; Reference: Reference; Shape: Shape; Size: Size; SustainabilityPerformance: SustainabilityPerformance; WarrantyDescription: WarrantyDescription; WarrantyDurationLabor: WarrantyDurationLabor; WarrantyDurationParts: WarrantyDurationParts; WarrantyGuarantorLabor: WarrantyGuarantorLabor; WarrantyGuarantorParts: WarrantyGuarantorParts; Classification Code: 23-75 70 14 31; Classification Description: Metal Ducts; ModelLabel: ModelLabel
PSet_Revit_Type_Construction - Roughness: 0.0003
PSet_Revit_Type_Identity Data - Manufacturer: Manufacturer
PSet_Revit_Type_Fitting - Elbow: M_Oval Elbow - Mitered: Oval Elbow - Mitered; Preferred Junction Type: 0; Tee: M_Oval Tee - Straight: Oval Tee - Straight; Tap: M_Oval Tap - Straight: Oval Tap - Straight; Cross: M_Oval Cross - Straight: Oval Cross - Straight; Transition: M_Oval Transition - Length: Oval Transition - Length; Multi Shape Transition Rect to Oval: M_Rectangular to Oval Transition - Length: Rectangular Oval Transition - Length; Multi Shape Transition Oval to Round: M_Oval to Round Transition - Length: Oval to Round Transition - Length; Union: M_Oval Union: Oval Union

# IfcFlowSegment: Oval Duct:Mitered Elbows / Taps:567887
In: Level 1
Type - ElementType: Oval Duct:Mitered Elbows / Taps:567887
PSet_Revit_Phasing - Phase Created: New Construction
PSet_Revit_Other - TagNumber: TagNumber; InstallationDate: InstallationDate; SerialNumber: SerialNumber; WarrantyStartDate: WarrantyStartDate; BarCode: BarCode; AssetIdentifier: AssetIdentifier
PSet_Revit_Constraints - Horizontal Justification: 0; Vertical Justification: 0; Reference Level: Level 1; Offset: 3.7 m; Start Offset: 3.7 m; End Offset: 3.7 m; Slope: 0
PSet_Revit_Dimensions - Size: 1500/500; Width: 4.92126; Height: 1.64042; Length: 2.14101 m
PSet_Revit_Identity Data - Mark: 695
PSet_Revit_Mechanical - Airflow - Flow: 0; Additional Flow: 0; Velocity: 0; Friction: 0; Pressure Drop: 0; Velocity Pressure: 0; Reynolds number: 0
PSet_Revit_Mechanical - System Type: Supply Air; System Name: Mechanical Supply Air 1; Bottom Elevation: 3.45 m; Top Elevation: 3.95 m; Equivalent Diameter: 2.95048; Size Lock: no; Loss Coefficient: 0; Hydraulic Diameter: 2.55922; Section: 788; Insulation Thickness: 0; Lining Thickness: 0; Area: 7.64511 m2
