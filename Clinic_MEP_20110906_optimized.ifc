Properties of the parts of a building model (IFC2X3), part 10 of 295

# IfcFlowFitting: 45 Degree (707)
Name | In | Length 2 | Length 1 | Mark | System Type | System Name | ASHRAE Table | Level | Host | Offset (m) | Size | OffsetHeight | OffsetWidth | Num8 | Num7 | Num6 | Num5 | Num4 | Num3 | Num2 | Num1 | PSet_Revit_Other, Delta 2 | PSet_Revit_Other, Delta 1 | WidthOffset | WidthDelta | Width2 = Lining Width 2 = Insulation Width 2 | Width1 = Lining Width 1 = Insulation Width 1 | MaxDelta = Length 01 = Computed Length | Lining Height 2 = Insulation Height 2 = Height2 | Lining Height 1 = Insulation Height 1 = Height1 | HeightOffset | HeightDelta | Half Width 2 | Half Width 1 | Half Height 2 | Half Height 1
M_Rectangular Transition - Angle:45 Degree:45 Degree:569614 | 2BC4 | 0.396032 | 0.198016 | 7436 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07048 | 350x300-250x300 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.82021 | 1.14829 | 0.396032 | 0.984252 | 0.984252 | 10 | 0 | 0.410105 | 0.574147 | 0.492126 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570328 | 2B21 | 0.082021 | 0.082021 | 8896 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568790 | 1E24 | 0.082021 | 0.082021 | 5589 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Round Transition - Angle:45 Degree:45 Degree:569528 | 2BC3 | 0.246063 | 0.246063 | 7199 | Supply Air | Mechanical Supply Air 2 | SD4-1 | Roof - Main | Level : Roof - Main | -1.08 | 400ø-250ø | 0.656168 | 0.656168 | PSet_Revit_Other - Num 1: 2.95276; Num 5: 7.12858; Num 4: 1; Num 3: 5.90551; Num 2: 2.95276; Length 3: 2.13163e-14; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0546807; OffsetHeightTemp: 0.0546807; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.246063; R1: 0.410105; R0: 0.656168; Lining Radius 1: 0.410105; Lining Radius 0: 0.656168; Insulation Radius 1: 0.410105; Insulation Radius 0: 0.656168; HeightOffsetfromBase: 10; ComputedLength: 0.594049
M_Round Transition - Angle:45 Degree:45 Degree:569557 | 2BC6 | 0.082021 | 0.082021 | 7276 | Supply Air | Mechanical Supply Air 2 | SD4-1 | Roof - Main | Level : Roof - Main | -1.08 | 400ø-350ø | 0.656168 | 0.656168 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0546807; OffsetHeightTemp: 0.0546807; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.574147; R0: 0.656168; Lining Radius 1: 0.574147; Lining Radius 0: 0.656168; Insulation Radius 1: 0.574147; Insulation Radius 0: 0.656168; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570392 | 2D18 | 0.246063 | 0.246063 | 8931 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:569412 | 2A01 | 0.396032 | 0.198016 | 6827 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07048 | 350x300-250x300 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.82021 | 1.14829 | 0.396032 | 0.984252 | 0.984252 | 10 | 0 | 0.410105 | 0.574147 | 0.492126 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570357 | 2D03 | 0.164042 | 0.164042 | 8912 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570334 | 2B15 | 0.164042 | 0.164042 | 8899 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:567355 | 1BC4 | 0.198016 | 0.198016 | 1766 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.3 | 300x150-250x150 | 0.246063 | 0.492126 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.198016 | 0.492126 | 0.492126 | 10 | 0 | 0.410105 | 0.492126 | 0.246063 | 0.246063
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568707 | 1E28 | 0.082021 | 0.082021 | 5528 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570366 | 2D18 | 0.246063 | 0.246063 | 8917 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567498 | 1BC2 | 0.396032 | 0.198016 | 2269 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.37 | 200x200-100x200 | 0.328084 | 0.328084 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.328084 | 0.656168 | 0.396032 | 0.656168 | 0.656168 | 10 | 0 | 0.164042 | 0.328084 | 0.328084 | 0.328084
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570354 | 2D21 | 0.082021 | 0.082021 | 8910 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570297 | 2A04 | 0.082021 | 0.082021 | 8879 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570343 | 2BC2 | 0.164042 | 0.164042 | 8904 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:566724 | 1EC1 | 0.396032 | 0.198016 | 191 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.755 | 700x250-600x250 | 0.410105 | 1.14829 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 1.9685 | 2.29659 | 0.396032 | 0.82021 | 0.82021 | 10 | 0 | 0.984252 | 1.14829 | 0.410105 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570319 | 2B10 | 0.164042 | 0.164042 | 8891 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568258 | 1D13 | 0.246063 | 0.246063 | 4729 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570406 | 2DC2 | 0.246063 | 0.246063 | 8939 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567350 | 1BC4 | 0.198016 | 0.198016 | 1763 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.3 | 300x150-250x150 | 0.246063 | 0.492126 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.198016 | 0.492126 | 0.492126 | 10 | 0 | 0.410105 | 0.492126 | 0.246063 | 0.246063
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568699 | 1E24 | 0.082021 | 0.082021 | 5523 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570308 | 2B24 | 0.082021 | 0.082021 | 8885 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570372 | 2D04-A | 0 | 0 | 8920 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-300ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 0; Num 7: 0; Num 6: 0; Num 10: 0; Num 1: 0; Length 8: 0; Length 7: 0; Length 6: 0; Length 5: 0; Length 4: 0; Half H0: 0.492126; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0; Delta 1: 0; W0: 0.984252; Radius: 0.492126; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.492126; Lining H0: 0.984252; Length01: 0.246063; Insulation W0: 0.984252; Insulation Radius: 0.492126; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.984252
M_Rectangular Transition - Angle:45 Degree:45 Degree:569620 | 2B19 | 0.297024 | 0.198016 | 7453 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07045 | 275x250-200x250 | 0.409941 | 0.451115 | 1 | 1 | 1 | 1 | 1.5 | 2.25 | 1.5 | 1.5 | 0.000164042 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.297024 | 0.82021 | 0.82021 | 9.99984 | 0 | 0.328084 | 0.451115 | 0.410105 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568780 | 1E29 | 0.082021 | 0.082021 | 5583 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular Transition - Angle:45 Degree:45 Degree:567356 | 1BC4 | 0.198016 | 0.198016 | 1768 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.3 | 250x150-250x100 | 0.246063 | 0.410105 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.82021 | 0.82021 | 0.198016 | 0.328084 | 0.492126 | 10 | 0.164042 | 0.410105 | 0.410105 | 0.164042 | 0.246063
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570330 | 2B18 | 0.082021 | 0.082021 | 8897 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568653 | 1D27 | 0.164042 | 0.164042 | 5495 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570293 | 2AC3 | 0.246063 | 0.246063 | 8877 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570314 | 2B4 | 0.164042 | 0.164042 | 8888 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:567371 | Level 1 | 0.0990081 | 0.393907 | 1794 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.79953 | 275x250-300x150 | 0.378773 | 0.451115 | 2 | 4 | 1.618 | 2.382 | 0.5 | 0.25 | 0.5 | 0.5 | 0.031332 | 0 | 10 | 0.082021 | 0.984252 | 0.902231 | 0.393907 | 0.492126 | 0.82021 | 9.96867 | 0.328084 | 0.492126 | 0.451115 | 0.246063 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570248 | 2C03 | 0.164042 | 0.164042 | 8853 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:570000 | 2D08 | 0.198016 | 0.198016 | 8386 | Return Air | Mechanical Return Air 2 |  | Roof - Main | Level : Roof - Main | -0.68 | 350x250-350x200 | 0.410105 | 0.574147 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.198016 | 0.656168 | 0.82021 | 10 | 0.164042 | 0.574147 | 0.574147 | 0.328084 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570347 | 2D21 | 0.082021 | 0.082021 | 8906 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular Transition - Angle:45 Degree:45 Degree:569426 | 2A05 | 0.495041 | 0.198016 | 6857 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07045 | 275x250-150x300 | 0.409941 | 0.451115 | 1 | 1 | 0.998 | 1.002 | 2.5 | 6.25 | 2.5 | 2.5 | 0.000164042 | 0 | 10 | 0.410105 | 0.492126 | 0.902231 | 0.495041 | 0.984252 | 0.82021 | 9.99984 | 0.164042 | 0.246063 | 0.451115 | 0.492126 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570345 | 2BC2 | 0.164042 | 0.164042 | 8905 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568625 | 1D16 | 0.164042 | 0.164042 | 5476 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:569431 | 2A05 | 0.495041 | 0.396032 | 6864 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07045 | 275x250-150x350 | 0.409941 | 0.451115 | 2 | 4 | 1.998 | 2.002 | 2.5 | 6.25 | 2.5 | 2.5 | 0.000164042 | 0 | 10 | 0.410105 | 0.492126 | 0.902231 | 0.495041 | 1.14829 | 0.82021 | 9.99984 | 0.328084 | 0.246063 | 0.451115 | 0.574147 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570383 | 2D14 | 0.082021 | 0.082021 | 8926 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568450 | 1CC1 | 0.164042 | 0.164042 | 5250 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 2 | Level : Level 2 | -1.6684 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:569941 | 2D19 | 0.198016 | 0.396032 | 8303 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.78 | 450x250-450x150 | 0.410105 | 0.738189 | 2 | 4 | 2 | 2 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.47638 | 1.47638 | 0.396032 | 0.492126 | 0.82021 | 10 | 0.328084 | 0.738189 | 0.738189 | 0.246063 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570256 | 2CC1 | 0.246063 | 0.246063 | 8857 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:567095 | 1EC2 | 0.594049 | 0.198016 | 1198 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.79 | 500x200-350x150 | 0.246063 | 0.574147 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 1.64042 | 1.14829 | 0.594049 | 0.656168 | 0.492126 | 10 | 0.164042 | 0.82021 | 0.574147 | 0.328084 | 0.246063
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570324 | 2BC5 | 0.246063 | 0.246063 | 8894 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:566979 | 1DC1 | 0.792065 | 0.594049 | 966 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.29858 | 300x300-500x150 | 0.492126 | 0.492126 | 3 | 9 | 3 | 3 | 4 | 16 | 4 | 4 | 0 | 0 | 10 | 0.656168 | 1.64042 | 0.984252 | 0.792065 | 0.492126 | 0.984252 | 10 | 0.492126 | 0.82021 | 0.492126 | 0.246063 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568656 | 1D23 | 0.082021 | 0.082021 | 5497 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568774 | 1D10 | 0.164042 | 0.164042 | 5579 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Round Transition - Angle:45 Degree:45 Degree:568266 | 1DC3 | 0.082021 | 0.082021 | 4751 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 2 | Level : Level 2 | -0.87 | 500ø-450ø | 0.82021 | 0.82021 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0683508; OffsetHeightTemp: 0.0683508; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.738189; R0: 0.82021; Lining Radius 1: 0.738189; Lining Radius 0: 0.82021; Insulation Radius 1: 0.738189; Insulation Radius 0: 0.82021; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Round Transition - Angle:45 Degree:45 Degree:996435 | 1EC1 | 0.245319 | 0.246807 | 143 | Supply Air | Mechanical Supply Air 1 | SD4-1 | Level 1 | Level : Level 1 | 3.79 | 350ø-200ø | 0.574147 | 0.573403 | PSet_Revit_Other - Num 1: 2.96168; Num 5: 7.12857; Num 4: 1; Num 3: 5.90551; Num 2: 2.94383; Length 3: 0.000744086; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0477836; OffsetHeightTemp: 0.0478456; WidthOffsetfromBase: 9.99926; Offest Delta: 2.66454e-14; DiameterDelta: 0.246063; R1: 0.328084; R0: 0.574147; Lining Radius 1: 0.328084; Lining Radius 0: 0.574147; Insulation Radius 1: 0.328084; Insulation Radius 0: 0.574147; HeightOffsetfromBase: 10; ComputedLength: 0.594048
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:569844 | 2B3 | 0 | 0 | 8032 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-300ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 0; Num 7: 0; Num 6: 0; Num 10: 0; Num 1: 0; Length 8: 0; Length 7: 0; Length 6: 0; Length 5: 0; Length 4: 0; Half H0: 0.492126; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0; Delta 1: 0; W0: 0.984252; Radius: 0.492126; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.492126; Lining H0: 0.984252; Length01: 0.246063; Insulation W0: 0.984252; Insulation Radius: 0.492126; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.984252
M_Rectangular Transition - Angle:45 Degree:45 Degree:569451 | 2A12 | 0.495041 | 0.198016 | 6933 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07048 | 425x350-300x350 | 0.574147 | 0.697178 | 1 | 1 | 1 | 1 | 2.5 | 6.25 | 2.5 | 2.5 | 0 | 0 | 10 | 0.410105 | 0.984252 | 1.39436 | 0.495041 | 1.14829 | 1.14829 | 10 | 0 | 0.492126 | 0.697178 | 0.574147 | 0.574147
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568797 | 1D20 | 0.164042 | 0.164042 | 5593 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568766 | 1A06 | 0.082021 | 0.082021 | 5572 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570360 | 2D04 | 0.164042 | 0.164042 | 8914 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568438 | 1AC3 | 0.246063 | 0.246063 | 5232 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570258 | 2CC3 | 0.246063 | 0.246063 | 8858 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-150ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 6; Num 7: 3; Num 6: 3; Num 10: 7.24264; Num 1: 3; Length 8: 0.594049; Length 7: 0.594049; Length 6: 0.246063; Length 5: 0.246063; Length 4: 0; Half H0: 0.492126; Num 5: 7.24264; Num 4: 1; Num 3: 6; Num 2: 3; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.246063; Delta 1: 0.246063; W0: 0.984252; Radius: 0.246063; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.246063; Lining H0: 0.984252; Length01: 0.594049; Insulation W0: 0.984252; Insulation Radius: 0.246063; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570413 | 2C09 | 0 | 0 | 8944 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-300ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 0; Num 7: 0; Num 6: 0; Num 10: 0; Num 1: 0; Length 8: 0; Length 7: 0; Length 6: 0; Length 5: 0; Length 4: 0; Half H0: 0.492126; Num 5: 0; Num 4: 1; Num 3: 0; Num 2: 0; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0; Delta 1: 0; W0: 0.984252; Radius: 0.492126; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.492126; Lining H0: 0.984252; Length01: 0.246063; Insulation W0: 0.984252; Insulation Radius: 0.492126; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.984252
M_Rectangular Transition - Angle:45 Degree:45 Degree:569848 | 2B01 | 0.495041 | 0.198016 | 8044 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07045 | 275x250-150x300 | 0.409941 | 0.451115 | 1 | 1 | 0.998 | 1.002 | 2.5 | 6.25 | 2.5 | 2.5 | 0.000164042 | 0 | 10 | 0.410105 | 0.492126 | 0.902231 | 0.495041 | 0.984252 | 0.82021 | 9.99984 | 0.164042 | 0.246063 | 0.451115 | 0.492126 | 0.410105
M_Rectangular Transition - Angle:45 Degree:45 Degree:567366 | 1BC4 | 0.198016 | 0.198016 | 1783 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.3 | 300x100-250x100 | 0.164042 | 0.492126 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0.164042 | 0.82021 | 0.984252 | 0.198016 | 0.328084 | 0.328084 | 10 | 0 | 0.410105 | 0.492126 | 0.164042 | 0.164042
M_Rectangular Transition - Angle:45 Degree:45 Degree:569415 | 2A14 | 0.396032 | 0.198016 | 6832 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07048 | 350x300-250x250 | 0.492126 | 0.574147 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.82021 | 1.14829 | 0.396032 | 0.82021 | 0.984252 | 10 | 0.164042 | 0.410105 | 0.574147 | 0.410105 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568719 | 1B04 | 0.082021 | 0.082021 | 5537 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 350ø-300x300 | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.574147; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.574147; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.574147; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 1.14829
M_Rectangular Transition - Angle:45 Degree:45 Degree:569535 | 2B21 | 0.495041 | 0.198016 | 7217 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07045 | 275x250-150x300 | 0.409941 | 0.451115 | 1 | 1 | 0.998 | 1.002 | 2.5 | 6.25 | 2.5 | 2.5 | 0.000164042 | 0 | 10 | 0.410105 | 0.492126 | 0.902231 | 0.495041 | 0.984252 | 0.82021 | 9.99984 | 0.164042 | 0.246063 | 0.451115 | 0.492126 | 0.410105
M_Round Transition - Angle:45 Degree:45 Degree:569559 | 2BC5 | 0.082021 | 0.082021 | 7287 | Supply Air | Mechanical Supply Air 2 | SD4-1 | Roof - Main | Level : Roof - Main | -1.08 | 350ø-300ø | 0.574147 | 0.574147 | PSet_Revit_Other - Num 1: 0.984252; Num 5: 2.37619; Num 4: 1; Num 3: 1.9685; Num 2: 0.984252; Length 3: 0; PSet_Revit_Dimensions - OffsetWidthTemp: 0.0478456; OffsetHeightTemp: 0.0478456; WidthOffsetfromBase: 10; Offest Delta: 0; DiameterDelta: 0.082021; R1: 0.492126; R0: 0.574147; Lining Radius 1: 0.492126; Lining Radius 0: 0.574147; Insulation Radius 1: 0.492126; Insulation Radius 0: 0.574147; HeightOffsetfromBase: 10; ComputedLength: 0.198016
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570374 | 2D19 | 0.082021 | 0.082021 | 8921 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular Transition - Angle:45 Degree:45 Degree:569220 | 2C17 | 0.495041 | 0.396032 | 6291 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.27048 | 475x450-350x350 | 0.738189 | 0.779199 | 2 | 4 | 2 | 2 | 2.5 | 6.25 | 2.5 | 2.5 | 0 | 0 | 10 | 0.410105 | 1.14829 | 1.5584 | 0.495041 | 1.14829 | 1.47638 | 10 | 0.328084 | 0.574147 | 0.779199 | 0.574147 | 0.738189
M_Rectangular Transition - Angle:45 Degree:45 Degree:566948 | 1CC1 | 0.198016 | 0.792065 | 910 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 2 | Level : Level 2 | -0.93 | 350x400-350x200 | 0.656168 | 0.574147 | 4 | 16 | 4 | 4 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 1.14829 | 1.14829 | 0.792065 | 0.656168 | 1.31234 | 10 | 0.656168 | 0.574147 | 0.574147 | 0.328084 | 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568642 | 1D22 | 0.082021 | 0.082021 | 5488 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570341 | 2B9 | 0.164042 | 0.164042 | 8903 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:567324 | 1E24 | 0.594049 | 0.198016 | 1661 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 1 | Level : Level 1 | 3.79 | 450x300-300x300 | 0.492126 | 0.738189 | 1 | 1 | 1 | 1 | 3 | 9 | 3 | 3 | 0 | 0 | 10 | 0.492126 | 0.984252 | 1.47638 | 0.594049 | 0.984252 | 0.984252 | 10 | 0 | 0.492126 | 0.738189 | 0.492126 | 0.492126
M_Rectangular Transition - Angle:45 Degree:45 Degree:566952 | 1C09 | 0.396032 | 0.198016 | 915 | Return Air | Mechanical Return Air 1 | ER4-1 | Level 1 | Level : Level 1 | 3.39429 | 300x300-200x350 | 0.492126 | 0.492126 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.656168 | 0.984252 | 0.396032 | 1.14829 | 0.984252 | 10 | 0.164042 | 0.328084 | 0.492126 | 0.574147 | 0.492126
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568701 | 1E26 | 0.164042 | 0.164042 | 5524 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:567606 | 1D25 | 0.164042 | 0.164042 | 2597 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:569640 | 2B19 | 0.198016 | 0.198016 | 7495 | Supply Air | Default Supply Air (cskender) | SR4-1 | Level 2 | Level : Level 2 | 3.60952 | 250x200-250x150 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 0 | 0 | 10 | 0 | 0.82021 | 0.82021 | 0.198016 | 0.492126 | 0.656168 | 10 | 0.164042 | 0.410105 | 0.410105 | 0.246063 | 0.328084
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568607 | 1CC3 | 0.082021 | 0.082021 | 5464 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-250ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 2; Num 7: 1; Num 6: 1; Num 10: 2.41421; Num 1: 1; Length 8: 0.198016; Length 7: 0.198016; Length 6: 0.082021; Length 5: 0.082021; Length 4: 0; Half H0: 0.492126; Num 5: 2.41421; Num 4: 1; Num 3: 2; Num 2: 1; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.082021; Delta 1: 0.082021; W0: 0.984252; Radius: 0.410105; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.410105; Lining H0: 0.984252; Length01: 0.198016; Insulation W0: 0.984252; Insulation Radius: 0.410105; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.82021
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:570262 | 2A10 | 0.164042 | 0.164042 | 8860 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:568280 | 1D10 | 0.297024 | 0.198016 | 4808 | Supply Air | Mechanical Supply Air 1 | SR4-1 | Level 2 | Level : Level 2 | -0.86047 | 275x250-200x250 | 0.409941 | 0.451115 | 1 | 1 | 1 | 1 | 1.5 | 2.25 | 1.5 | 1.5 | 0.000164042 | 0 | 10 | 0.246063 | 0.656168 | 0.902231 | 0.297024 | 0.82021 | 0.82021 | 9.99984 | 0 | 0.328084 | 0.451115 | 0.410105 | 0.410105
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568729 | 1BC1 | 0.164042 | 0.164042 | 5542 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:568604 | 1C14 | 0.164042 | 0.164042 | 5462 | Supply Air | Mechanical Supply Air 1 | SR4-3 | Level 1 | Level : Level 1 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular to Round Transition - Angle:45 Degree:45 Degree:569729 | 2DC1 | 0.164042 | 0.164042 | 7747 | Supply Air | Mechanical Supply Air 2 | SR4-3 | Level 2 | Level : Level 2 | 2.9016 | 300x300-200ø | 0.492126 | 0.492126 | PSet_Revit_Other - Num 9: 1; Num 8: 4; Num 7: 2; Num 6: 2; Num 10: 4.82843; Num 1: 2; Length 8: 0.396032; Length 7: 0.396032; Length 6: 0.164042; Length 5: 0.164042; Length 4: 0; Half H0: 0.492126; Num 5: 4.82843; Num 4: 1; Num 3: 4; Num 2: 2; Length 3: 0; Half W0: 0.492126; PSet_Revit_Dimensions - Delta 2: 0.164042; Delta 1: 0.164042; W0: 0.984252; Radius: 0.328084; OffsetWidthfromBase: 10; OffsetHeightfromBase: 10; Lining W0: 0.984252; Lining Radius: 0.328084; Lining H0: 0.984252; Length01: 0.396032; Insulation W0: 0.984252; Insulation Radius: 0.328084; Insulation H0: 0.984252; H0: 0.984252; OffsetWidthTemp: -0.0416667; OffsetHeightTemp: 0.0416667; Diameter: 0.656168
M_Rectangular Transition - Angle:45 Degree:45 Degree:569931 | 2D14 | 0.396032 | 0.198016 | 8239 | Return Air | Mechanical Return Air 2 | ER4-1 | Roof - Main | Level : Roof - Main | -0.78 | 600x350-500x350 | 0.574147 | 0.984252 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 1.64042 | 1.9685 | 0.396032 | 1.14829 | 1.14829 | 10 | 0 | 0.82021 | 0.984252 | 0.574147 | 0.574147
M_Rectangular Transition - Angle:45 Degree:45 Degree:569420 | 2A02 | 0.396032 | 0.198016 | 6845 | Supply Air | Mechanical Supply Air 2 | SR4-1 | Roof - Main | Level : Roof - Main | -1.07048 | 250x200-150x250 | 0.328084 | 0.410105 | 1 | 1 | 1 | 1 | 2 | 4 | 2 | 2 | 0 | 0 | 10 | 0.328084 | 0.492126 | 0.82021 | 0.396032 | 0.82021 | 0.656168 | 10 | 0.164042 | 0.246063 | 0.410105 | 0.410105 | 0.328084
